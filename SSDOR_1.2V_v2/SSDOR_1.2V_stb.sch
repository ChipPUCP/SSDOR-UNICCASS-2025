v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 2400 -590 {}
P 4 1 1480 -1520 {}
P 4 1 1840 -470 {}
N 1360 -800 1380 -800 {lab=Vp}
N 1360 -660 1400 -660 {lab=Vout_1}
N 1460 -800 1480 -800 {lab=Vn}
N 1440 -660 1480 -660 {lab=Vout_1}
N 1520 -730 1520 -690 {lab=Vb3}
N 1520 -770 1520 -730 {lab=Vb3}
N 1320 -730 1320 -690 {lab=Vb1}
N 1290 -730 1320 -730 {lab=Vb1}
N 1320 -770 1320 -730 {lab=Vb1}
N 1380 -800 1380 -610 {lab=Vp}
N 1320 -610 1380 -610 {lab=Vp}
N 1200 -700 1200 -610 {lab=Vp}
N 1640 -700 1640 -610 {lab=Vn}
N 1460 -800 1460 -610 {lab=Vn}
N 1520 -610 1640 -610 {lab=Vn}
N 1440 -850 1440 -660 {lab=Vout_1}
N 1520 -850 1640 -850 {lab=Vout_1}
N 1400 -850 1400 -660 {lab=Vout_1}
N 1420 -290 1640 -290 {lab=GND}
N 1640 -430 1640 -380 {lab=Vn}
N 1200 -430 1200 -380 {lab=Vp}
N 1240 -350 1280 -350 {lab=Vn}
N 1560 -350 1600 -350 {lab=Vp}
N 1280 -350 1560 -430 {lab=Vn}
N 1280 -430 1560 -350 {lab=Vp}
N 1200 -430 1280 -430 {lab=Vp}
N 1200 -570 1200 -430 {lab=Vp}
N 1560 -430 1640 -430 {lab=Vn}
N 1640 -470 1640 -430 {lab=Vn}
N 1120 -490 1120 -470 {lab=Vn}
N 1120 -470 1640 -470 {lab=Vn}
N 1640 -570 1640 -470 {lab=Vn}
N 1120 -570 1120 -550 {lab=Vp}
N 1120 -570 1200 -570 {lab=Vp}
N 1200 -610 1200 -570 {lab=Vp}
N 1290 -800 1320 -800 {lab=Vb1}
N 1290 -800 1290 -730 {lab=Vb1}
N 1290 -660 1320 -660 {lab=Vb1}
N 1290 -730 1290 -660 {lab=Vb1}
N 1520 -800 1550 -800 {lab=Vb3}
N 1550 -800 1550 -730 {lab=Vb3}
N 1520 -730 1550 -730 {lab=Vb3}
N 1520 -660 1550 -660 {lab=Vb3}
N 1550 -730 1550 -660 {lab=Vb3}
N 530 -700 530 -610 {lab=Vp}
N 530 -850 530 -760 {lab=#net1}
N 1200 -890 1200 -850 {lab=Vout_1}
N 1200 -890 1640 -890 {lab=Vout_1}
N 1640 -890 1640 -850 {lab=Vout_1}
N 1420 -250 1420 -230 {lab=GND}
N 1200 -290 1420 -290 {lab=GND}
N 2540 -530 2540 -250 {lab=GND}
N 2620 -530 2620 -250 {lab=GND}
N 2540 -250 2620 -250 {lab=GND}
N 2540 -890 2540 -590 {lab=Vout_1}
N 2620 -690 2620 -590 {lab=#net2}
N 2620 -890 2620 -750 {lab=Vout_1}
N 1640 -350 1650 -350 {lab=GND}
N 1650 -350 1650 -320 {lab=GND}
N 1640 -320 1650 -320 {lab=GND}
N 1640 -320 1640 -290 {lab=GND}
N 1200 -320 1200 -290 {lab=GND}
N 1190 -350 1200 -350 {lab=GND}
N 1190 -350 1190 -320 {lab=GND}
N 1190 -320 1200 -320 {lab=GND}
N 960 -730 1160 -730 {lab=#net3}
N 680 -780 680 -730 {lab=Vcomp1}
N 670 -730 680 -730 {lab=Vcomp1}
N 1320 -730 1330 -730 {lab=Vb1}
N 910 -690 910 -660 {lab=GND}
N 2310 -700 2310 -610 {lab=Vn}
N 2310 -850 2310 -760 {lab=Vout_1}
N 1930 -850 1930 -770 {lab=Vout_1}
N 1930 -690 1930 -660 {lab=GND}
N 1640 -610 2310 -610 {lab=Vn}
N 1640 -850 1930 -850 {lab=Vout_1}
N 1680 -730 1880 -730 {lab=#net4}
N 1360 -1120 1380 -1120 {lab=Vp}
N 1360 -980 1400 -980 {lab=Vout_2}
N 1460 -1120 1480 -1120 {lab=Vn}
N 1440 -980 1480 -980 {lab=Vout_2}
N 1520 -1050 1520 -1010 {lab=Vb4}
N 1520 -1090 1520 -1050 {lab=Vb4}
N 1320 -1050 1320 -1010 {lab=Vb2}
N 1290 -1050 1320 -1050 {lab=Vb2}
N 1320 -1090 1320 -1050 {lab=Vb2}
N 1320 -1170 1400 -1170 {lab=Vout_2}
N 1380 -1120 1380 -930 {lab=Vp}
N 1320 -930 1380 -930 {lab=Vp}
N 1200 -1020 1200 -930 {lab=Vp}
N 1640 -1020 1640 -930 {lab=Vn}
N 1460 -1120 1460 -930 {lab=Vn}
N 1520 -930 1640 -930 {lab=Vn}
N 1440 -1170 1440 -980 {lab=Vout_2}
N 1520 -1170 1640 -1170 {lab=Vout_2}
N 1400 -1170 1400 -980 {lab=Vout_2}
N 1290 -1120 1320 -1120 {lab=Vb2}
N 1290 -1120 1290 -1050 {lab=Vb2}
N 1290 -980 1320 -980 {lab=Vb2}
N 1290 -1050 1290 -980 {lab=Vb2}
N 1520 -1120 1550 -1120 {lab=Vb4}
N 1550 -1120 1550 -1050 {lab=Vb4}
N 1520 -1050 1550 -1050 {lab=Vb4}
N 1520 -980 1550 -980 {lab=Vb4}
N 1550 -1050 1550 -980 {lab=Vb4}
N 530 -1020 530 -930 {lab=Vp}
N 530 -1170 530 -1080 {lab=#net5}
N 960 -1050 1160 -1050 {lab=#net6}
N 680 -1100 680 -1050 {lab=Vcomp2}
N 670 -1050 680 -1050 {lab=Vcomp2}
N 1320 -1050 1330 -1050 {lab=Vb2}
N 910 -1010 910 -980 {lab=GND}
N 2310 -1020 2310 -930 {lab=Vn}
N 2310 -1170 2310 -1080 {lab=Vout_2}
N 1930 -1170 1930 -1090 {lab=Vout_2}
N 1930 -1010 1930 -980 {lab=GND}
N 1640 -930 2310 -930 {lab=Vn}
N 1640 -1170 1930 -1170 {lab=Vout_2}
N 1680 -1050 1880 -1050 {lab=#net7}
N 1200 -570 1410 -570 {lab=Vp}
N 1380 -930 1410 -930 {lab=Vp}
N 1410 -930 1410 -570 {lab=Vp}
N 1430 -930 1460 -930 {lab=Vn}
N 1430 -930 1430 -570 {lab=Vn}
N 1430 -570 1640 -570 {lab=Vn}
N 1640 -610 1640 -570 {lab=Vn}
N 2580 -950 2620 -950 {lab=GND}
N 2580 -950 2580 -930 {lab=GND}
N 2540 -950 2580 -950 {lab=GND}
N 1420 -290 1420 -250 {lab=GND}
N 2620 -1000 2620 -950 {lab=GND}
N 2540 -1000 2540 -950 {lab=GND}
N 2540 -1210 2540 -1060 {lab=Vout_2}
N 2620 -1100 2620 -1060 {lab=#net8}
N 2620 -1210 2620 -1160 {lab=Vout_2}
N 1200 -1210 1200 -1170 {lab=Vout_2}
N 1640 -1210 2540 -1210 {lab=Vout_2}
N 1640 -1210 1640 -1170 {lab=Vout_2}
N 1200 -1210 1640 -1210 {lab=Vout_2}
N 500 -730 530 -730 {lab=#net9}
N 1640 -890 2540 -890 {lab=Vout_1}
N 2540 -890 2620 -890 {lab=Vout_1}
N 2540 -1210 2620 -1210 {lab=Vout_2}
N 530 -610 1200 -610 {lab=Vp}
N 2070 -1170 2310 -1170 {lab=Vout_2}
N 2070 -850 2310 -850 {lab=Vout_1}
N 530 -930 1200 -930 {lab=Vp}
N 1420 -250 2540 -250 {lab=GND}
N 680 -1050 710 -1050 {lab=Vcomp2}
N 680 -730 710 -730 {lab=Vcomp1}
N 1450 -2050 1450 -2030 {lab=Vx1}
N 1350 -2050 1400 -2050 {lab=Vx1}
N 1350 -2050 1350 -2030 {lab=Vx1}
N 1380 -1990 1400 -1990 {lab=Vx1}
N 1400 -2050 1400 -1990 {lab=Vx1}
N 1400 -2050 1450 -2050 {lab=Vx1}
N 1400 -1990 1420 -1990 {lab=Vx1}
N 1400 -1890 1480 -1890 {lab=Vx1}
N 1400 -1990 1400 -1890 {lab=Vx1}
N 1440 -1830 1480 -1830 {lab=#net10}
N 1380 -1860 1380 -1790 {lab=Ibias_5}
N 1380 -1860 1480 -1860 {lab=Ibias_5}
N 1260 -1990 1260 -1970 {lab=GND}
N 1260 -1990 1350 -1990 {lab=GND}
N 1560 -1810 1560 -1790 {lab=GND}
N 1450 -1650 1450 -1630 {lab=Vx2}
N 1350 -1650 1400 -1650 {lab=Vx2}
N 1350 -1650 1350 -1630 {lab=Vx2}
N 1380 -1590 1400 -1590 {lab=Vx2}
N 1400 -1650 1400 -1590 {lab=Vx2}
N 1400 -1650 1450 -1650 {lab=Vx2}
N 1400 -1590 1420 -1590 {lab=Vx2}
N 1400 -1490 1480 -1490 {lab=Vx2}
N 1400 -1590 1400 -1490 {lab=Vx2}
N 1440 -1430 1480 -1430 {lab=#net11}
N 1380 -1460 1380 -1390 {lab=Ibias_6}
N 1380 -1460 1480 -1460 {lab=Ibias_6}
N 1260 -1590 1260 -1570 {lab=GND}
N 1260 -1590 1350 -1590 {lab=GND}
N 1560 -1410 1560 -1390 {lab=GND}
N 1560 -1950 1560 -1910 {lab=Vout_2}
N 1910 -1650 1910 -1630 {lab=GND}
N 1740 -1730 1830 -1730 {lab=X}
N 1620 -1460 1740 -1460 {lab=Y}
N 1680 -1950 1680 -1590 {lab=Vout_2}
N 1620 -1860 1740 -1860 {lab=X}
N 1740 -1860 1740 -1730 {lab=X}
N 1740 -1710 1740 -1460 {lab=Y}
N 1740 -1710 1830 -1710 {lab=Y}
N 1910 -1950 1940 -1950 {lab=Vout_2}
N 1990 -1690 2020 -1690 {lab=S2}
N 2020 -1730 2080 -1730 {lab=S1_p}
N 2140 -1990 2140 -1780 {lab=Vout_1}
N 2140 -1990 2180 -1990 {lab=Vout_1}
N 2140 -1680 2140 -1660 {lab=GND}
N 2200 -1730 2230 -1730 {lab=S1}
N 830 -730 860 -730 {lab=#net12}
N 770 -670 770 -650 {lab=GND}
N 770 -850 770 -790 {lab=#net1}
N 530 -850 770 -850 {lab=#net1}
N 710 -710 710 -680 {lab=S1}
N 710 -820 710 -750 {lab=Vout_1}
N 2130 -730 2170 -730 {lab=#net13}
N 1980 -730 2010 -730 {lab=#net14}
N 2070 -670 2070 -650 {lab=GND}
N 2070 -850 2070 -790 {lab=Vout_1}
N 2130 -710 2130 -680 {lab=S1}
N 2130 -820 2130 -750 {lab=Vout_1}
N 1930 -850 2070 -850 {lab=Vout_1}
N 830 -1050 860 -1050 {lab=#net15}
N 770 -990 770 -970 {lab=GND}
N 770 -1170 770 -1110 {lab=#net5}
N 710 -1030 710 -1000 {lab=S2}
N 710 -1140 710 -1070 {lab=Vout_2}
N 530 -1170 770 -1170 {lab=#net5}
N 2130 -1050 2170 -1050 {lab=#net16}
N 1980 -1050 2010 -1050 {lab=#net17}
N 2070 -990 2070 -970 {lab=GND}
N 2070 -1170 2070 -1110 {lab=Vout_2}
N 2130 -1030 2130 -1000 {lab=S2}
N 2130 -1140 2130 -1070 {lab=Vout_2}
N 1930 -1170 2070 -1170 {lab=Vout_2}
N 1560 -1590 1680 -1590 {lab=Vout_2}
N 1450 -1990 2140 -1990 {lab=Vout_1}
N 2020 -1790 2020 -1730 {lab=S1_p}
N 1990 -1730 2020 -1730 {lab=S1_p}
N 2310 -730 2350 -730 {lab=#net18}
N 2310 -1050 2350 -1050 {lab=#net19}
N 490 -1050 530 -1050 {lab=#net20}
N 1350 -1390 1380 -1390 {lab=Ibias_6}
N 1350 -1790 1380 -1790 {lab=Ibias_5}
N 1160 -1170 1200 -1170 {lab=Vout_2}
N 1160 -850 1200 -850 {lab=Vout_1}
N 910 -1170 910 -1160 {lab=#net5}
N 770 -1170 910 -1170 {lab=#net5}
N 910 -1100 910 -1090 {lab=#net21}
N 910 -780 910 -770 {lab=#net22}
N 910 -850 910 -840 {lab=#net1}
N 770 -850 910 -850 {lab=#net1}
N 1090 -1170 1100 -1170 {lab=#net5}
N 1090 -1200 1090 -1170 {lab=#net5}
N 910 -1200 910 -1170 {lab=#net5}
N 910 -1200 1090 -1200 {lab=#net5}
N 1100 -880 1100 -850 {lab=#net1}
N 910 -880 910 -850 {lab=#net1}
N 910 -880 1100 -880 {lab=#net1}
N 2410 -1050 2430 -1050 {lab=Ibias_4}
N 2410 -730 2430 -730 {lab=Ibias_2}
N 1510 -1050 1520 -1050 {lab=Vb4}
N 1510 -730 1520 -730 {lab=Vb3}
N 1560 -1590 1560 -1510 {lab=Vout_2}
N 1450 -1590 1560 -1590 {lab=Vout_2}
N 1560 -1950 1680 -1950 {lab=Vout_2}
N 1910 -1950 1910 -1770 {lab=Vout_2}
N 1680 -1950 1910 -1950 {lab=Vout_2}
N 1320 -850 1400 -850 {lab=Vout_1}
N 1320 -1170 1320 -1150 {lab=Vout_2}
N 1200 -1170 1320 -1170 {lab=Vout_2}
N 1520 -1170 1520 -1150 {lab=Vout_2}
N 1440 -1170 1520 -1170 {lab=Vout_2}
N 1320 -950 1320 -930 {lab=Vp}
N 1200 -930 1320 -930 {lab=Vp}
N 1200 -1170 1200 -1080 {lab=Vout_2}
N 1200 -1050 1290 -1050 {lab=Vb2}
N 1640 -1170 1640 -1080 {lab=Vout_2}
N 1550 -1050 1640 -1050 {lab=Vb4}
N 1640 -850 1640 -760 {lab=Vout_1}
N 1550 -730 1640 -730 {lab=Vb3}
N 1200 -850 1200 -760 {lab=Vout_1}
N 1200 -730 1290 -730 {lab=Vb1}
N 1320 -850 1320 -830 {lab=Vout_1}
N 1200 -850 1320 -850 {lab=Vout_1}
N 1520 -850 1520 -830 {lab=Vout_1}
N 1440 -850 1520 -850 {lab=Vout_1}
N 1320 -630 1320 -610 {lab=Vp}
N 1200 -610 1320 -610 {lab=Vp}
N 1520 -630 1520 -610 {lab=Vn}
N 1460 -610 1520 -610 {lab=Vn}
N 1520 -950 1520 -930 {lab=Vn}
N 1460 -930 1520 -930 {lab=Vn}
N 1790 -1690 1830 -1690 {lab=CLKg}
N 1790 -1590 1880 -1590 {lab=CLKg}
N 1790 -1690 1790 -1590 {lab=CLKg}
N 410 -730 440 -730 {lab=Ibias_1}
N 410 -1050 430 -1050 {lab=Ibias_3}
N 1440 -1430 1440 -1400 {lab=#net11}
N 1440 -1830 1440 -1790 {lab=#net10}
N -2290 -1190 -2290 -1160 {lab=Vout_2}
N 510 -1720 510 -1700 {lab=v1v}
N 1930 -1450 1960 -1450 {lab=Vout_2}
N 2040 -1380 2040 -1350 {lab=GND}
N 2120 -1450 2160 -1450 {lab=SEL2}
N 2410 -1440 2440 -1440 {lab=Vout_1}
N 2520 -1370 2520 -1340 {lab=GND}
N 2600 -1440 2640 -1440 {lab=SEL1}
N -2290 -1100 -2290 -990 {lab=#net23}
N 610 -1000 610 -980 {lab=GND}
N 610 -680 610 -660 {lab=GND}
N 2230 -680 2230 -660 {lab=GND}
N 2230 -1000 2230 -980 {lab=GND}
N -1650 -890 -1650 -810 {lab=voCTAT}
N -1890 -990 -1890 -890 {lab=#net23}
N -1430 -990 -1430 -890 {lab=#net23}
N -2770 -990 -2520 -990 {lab=#net23}
N -2080 -990 -2080 -890 {lab=#net23}
N -2150 -890 -2120 -890 {lab=voPTAT}
N -2300 -890 -2150 -890 {lab=voPTAT}
N -2520 -990 -2520 -890 {lab=#net23}
N -2300 -890 -2300 -810 {lab=voPTAT}
N -2440 -890 -2300 -890 {lab=voPTAT}
N -2240 -710 -2220 -710 {lab=#net23}
N -2220 -990 -2220 -710 {lab=#net23}
N -2290 -990 -2220 -990 {lab=#net23}
N -2520 -620 -2420 -620 {lab=GND}
N -2420 -620 -2420 -500 {lab=GND}
N -2520 -500 -2420 -500 {lab=GND}
N -2610 -620 -2560 -620 {lab=#net24}
N -2610 -560 -2610 -500 {lab=#net24}
N -2610 -500 -2560 -500 {lab=#net24}
N -2520 -670 -2520 -650 {lab=#net24}
N -2650 -560 -2610 -560 {lab=#net24}
N -2610 -620 -2610 -560 {lab=#net24}
N -2650 -670 -2650 -560 {lab=#net24}
N -2650 -670 -2520 -670 {lab=#net24}
N -2520 -860 -2520 -670 {lab=#net24}
N -2520 -550 -2520 -530 {lab=voSCCTP}
N -2310 -650 -2310 -570 {lab=#net25}
N -2770 -420 -2770 -380 {lab=#net26}
N -2770 -470 -2670 -470 {lab=GND}
N -2670 -470 -2670 -350 {lab=GND}
N -2770 -350 -2670 -350 {lab=GND}
N -2860 -470 -2810 -470 {lab=#net27}
N -2860 -410 -2860 -350 {lab=#net27}
N -2860 -350 -2810 -350 {lab=#net27}
N -2900 -410 -2860 -410 {lab=#net27}
N -2860 -470 -2860 -410 {lab=#net27}
N -2770 -420 -2520 -420 {lab=#net26}
N -2770 -440 -2770 -420 {lab=#net26}
N -2520 -470 -2520 -420 {lab=#net26}
N -2770 -530 -2770 -500 {lab=#net27}
N -2770 -990 -2770 -890 {lab=#net23}
N -2730 -940 -2730 -890 {lab=voPTAT}
N -2730 -940 -2440 -940 {lab=voPTAT}
N -2440 -940 -2440 -890 {lab=voPTAT}
N -2480 -890 -2440 -890 {lab=voPTAT}
N -2770 -330 -2770 -290 {lab=GND}
N -2900 -530 -2900 -410 {lab=#net27}
N -2900 -530 -2770 -530 {lab=#net27}
N -2770 -860 -2770 -530 {lab=#net27}
N -2420 -500 -2420 -290 {lab=GND}
N -2670 -290 -2420 -290 {lab=GND}
N -2670 -350 -2670 -290 {lab=GND}
N -2770 -290 -2670 -290 {lab=GND}
N -1890 -520 -1790 -520 {lab=#net23}
N -1570 -990 -1430 -990 {lab=#net23}
N -2080 -570 -2080 -550 {lab=vRPTAT}
N -2080 -490 -2080 -290 {lab=GND}
N -2290 -650 -2290 -570 {lab=vRPTAT}
N -2290 -570 -2080 -570 {lab=vRPTAT}
N -2080 -860 -2080 -570 {lab=vRPTAT}
N -1430 -570 -1430 -550 {lab=vRCTAT}
N -1640 -570 -1430 -570 {lab=vRCTAT}
N -1430 -860 -1430 -570 {lab=vRCTAT}
N -1640 -650 -1640 -570 {lab=vRCTAT}
N -1890 -860 -1890 -660 {lab=#net28}
N -1890 -490 -1890 -290 {lab=GND}
N -1890 -570 -1890 -550 {lab=voSCCTN}
N -1790 -630 -1790 -520 {lab=#net23}
N -1890 -990 -1790 -990 {lab=#net23}
N -1750 -710 -1710 -710 {lab=GND}
N -1750 -710 -1750 -290 {lab=GND}
N -1590 -710 -1570 -710 {lab=#net23}
N -1570 -990 -1570 -710 {lab=#net23}
N -1790 -990 -1570 -990 {lab=#net23}
N -2380 -710 -2360 -710 {lab=GND}
N -2380 -710 -2380 -290 {lab=GND}
N -1890 -630 -1790 -630 {lab=#net23}
N -1790 -990 -1790 -630 {lab=#net23}
N -490 -750 -460 -750 {lab=#net29}
N -160 -750 -110 -750 {lab=#net30}
N -1430 -490 -1430 -430 {lab=#net31}
N -1430 -370 -1430 -290 {lab=GND}
N -2420 -290 -2380 -290 {lab=GND}
N -1270 -990 -1270 -970 {lab=#net23}
N -1170 -990 -1080 -990 {lab=#net23}
N -1080 -990 -1080 -970 {lab=#net23}
N -1170 -940 -1080 -940 {lab=#net23}
N -1170 -990 -1170 -940 {lab=#net23}
N -1270 -990 -1170 -990 {lab=#net23}
N -1270 -940 -1170 -940 {lab=#net23}
N -1270 -910 -1270 -890 {lab=Ibias_1}
N -1170 -890 -1080 -890 {lab=Ibias_1}
N -1080 -910 -1080 -890 {lab=Ibias_1}
N -1270 -800 -1270 -780 {lab=#net23}
N -1170 -800 -1080 -800 {lab=#net23}
N -1080 -800 -1080 -780 {lab=#net23}
N -1170 -750 -1080 -750 {lab=#net23}
N -1170 -800 -1170 -750 {lab=#net23}
N -1270 -800 -1170 -800 {lab=#net23}
N -1270 -750 -1170 -750 {lab=#net23}
N -1270 -720 -1270 -700 {lab=Ibias_2}
N -1170 -700 -1080 -700 {lab=Ibias_2}
N -1080 -720 -1080 -700 {lab=Ibias_2}
N -1270 -600 -1270 -580 {lab=#net23}
N -1170 -600 -1080 -600 {lab=#net23}
N -1080 -600 -1080 -580 {lab=#net23}
N -1170 -550 -1080 -550 {lab=#net23}
N -1170 -600 -1170 -550 {lab=#net23}
N -1270 -600 -1170 -600 {lab=#net23}
N -1270 -550 -1170 -550 {lab=#net23}
N -1270 -520 -1270 -500 {lab=Ibias_3}
N -1170 -500 -1080 -500 {lab=Ibias_3}
N -1080 -520 -1080 -500 {lab=Ibias_3}
N -920 -600 -920 -580 {lab=#net23}
N -820 -600 -730 -600 {lab=#net23}
N -730 -600 -730 -580 {lab=#net23}
N -820 -550 -730 -550 {lab=#net23}
N -820 -600 -820 -550 {lab=#net23}
N -920 -600 -820 -600 {lab=#net23}
N -920 -550 -820 -550 {lab=#net23}
N -920 -520 -920 -500 {lab=Ibias_6}
N -820 -500 -730 -500 {lab=Ibias_6}
N -730 -520 -730 -500 {lab=Ibias_6}
N -920 -990 -920 -970 {lab=#net23}
N -820 -990 -730 -990 {lab=#net23}
N -730 -990 -730 -970 {lab=#net23}
N -820 -940 -730 -940 {lab=#net23}
N -820 -990 -820 -940 {lab=#net23}
N -920 -990 -820 -990 {lab=#net23}
N -920 -940 -820 -940 {lab=#net23}
N -920 -910 -920 -890 {lab=Ibias_4}
N -820 -890 -730 -890 {lab=Ibias_4}
N -730 -910 -730 -890 {lab=Ibias_4}
N -920 -800 -920 -780 {lab=#net23}
N -730 -800 -730 -780 {lab=#net23}
N -820 -750 -730 -750 {lab=#net23}
N -820 -800 -820 -750 {lab=#net23}
N -920 -750 -820 -750 {lab=#net23}
N -920 -720 -920 -700 {lab=Ibias_5}
N -820 -700 -730 -700 {lab=Ibias_5}
N -730 -720 -730 -700 {lab=Ibias_5}
N -820 -800 -730 -800 {lab=#net23}
N -1170 -890 -1170 -850 {lab=Ibias_1}
N -1270 -890 -1170 -890 {lab=Ibias_1}
N -1170 -700 -1170 -660 {lab=Ibias_2}
N -1270 -700 -1170 -700 {lab=Ibias_2}
N -1170 -500 -1170 -460 {lab=Ibias_3}
N -1270 -500 -1170 -500 {lab=Ibias_3}
N -820 -500 -820 -460 {lab=Ibias_6}
N -920 -500 -820 -500 {lab=Ibias_6}
N -820 -890 -820 -850 {lab=Ibias_4}
N -920 -890 -820 -890 {lab=Ibias_4}
N -820 -700 -820 -660 {lab=Ibias_5}
N -920 -700 -820 -700 {lab=Ibias_5}
N -920 -800 -820 -800 {lab=#net23}
N -590 -990 -590 -970 {lab=#net23}
N -490 -990 -400 -990 {lab=#net23}
N -400 -990 -400 -970 {lab=#net23}
N -490 -940 -400 -940 {lab=#net23}
N -490 -990 -490 -940 {lab=#net23}
N -590 -990 -490 -990 {lab=#net23}
N -590 -940 -490 -940 {lab=#net23}
N -590 -910 -590 -890 {lab=#net32}
N -400 -910 -400 -890 {lab=#net32}
N -730 -990 -590 -990 {lab=#net23}
N -260 -990 -260 -970 {lab=#net23}
N -160 -990 -70 -990 {lab=#net23}
N -70 -990 -70 -970 {lab=#net23}
N -160 -940 -70 -940 {lab=#net23}
N -160 -990 -160 -940 {lab=#net23}
N -260 -990 -160 -990 {lab=#net23}
N -260 -940 -160 -940 {lab=#net23}
N -260 -910 -260 -890 {lab=#net33}
N -70 -910 -70 -890 {lab=#net33}
N -400 -990 -260 -990 {lab=#net23}
N -1330 -750 -1330 -550 {lab=voPTAT}
N -640 -1080 -640 -940 {lab=voPTAT}
N -310 -1080 -310 -940 {lab=voPTAT}
N -20 -1040 -20 -940 {lab=voCTAT}
N -350 -1040 -20 -1040 {lab=voCTAT}
N -350 -1040 -350 -940 {lab=voCTAT}
N -2150 -1080 -2150 -890 {lab=voPTAT}
N -1830 -1040 -1830 -890 {lab=voCTAT}
N -2020 -290 -2020 -260 {lab=GND}
N -2080 -290 -2020 -290 {lab=GND}
N -1020 -1040 -670 -1040 {lab=voCTAT}
N -2080 -990 -1890 -990 {lab=#net23}
N -1950 -290 -1890 -290 {lab=GND}
N -1950 -630 -1930 -630 {lab=GND}
N -1950 -630 -1950 -520 {lab=GND}
N -1950 -520 -1930 -520 {lab=GND}
N -1950 -520 -1950 -290 {lab=GND}
N -2020 -290 -1950 -290 {lab=GND}
N -1000 -800 -920 -800 {lab=#net23}
N -1000 -990 -920 -990 {lab=#net23}
N -1000 -600 -920 -600 {lab=#net23}
N -670 -1040 -350 -1040 {lab=voCTAT}
N -1000 -990 -1000 -800 {lab=#net23}
N -1080 -990 -1000 -990 {lab=#net23}
N -1080 -800 -1000 -800 {lab=#net23}
N -1000 -800 -1000 -600 {lab=#net23}
N -1080 -600 -1000 -600 {lab=#net23}
N -670 -750 -670 -550 {lab=voCTAT}
N -690 -550 -670 -550 {lab=voCTAT}
N -690 -750 -670 -750 {lab=voCTAT}
N -670 -940 -670 -750 {lab=voCTAT}
N -690 -940 -670 -940 {lab=voCTAT}
N -670 -1040 -670 -940 {lab=voCTAT}
N -980 -750 -980 -550 {lab=voPTAT}
N -980 -550 -960 -550 {lab=voPTAT}
N -980 -750 -960 -750 {lab=voPTAT}
N -980 -940 -980 -750 {lab=voPTAT}
N -980 -940 -960 -940 {lab=voPTAT}
N -980 -1080 -980 -940 {lab=voPTAT}
N -1020 -750 -1020 -550 {lab=voCTAT}
N -1040 -550 -1020 -550 {lab=voCTAT}
N -1040 -750 -1020 -750 {lab=voCTAT}
N -1020 -940 -1020 -750 {lab=voCTAT}
N -1040 -940 -1020 -940 {lab=voCTAT}
N -1020 -1040 -1020 -940 {lab=voCTAT}
N -1330 -1080 -980 -1080 {lab=voPTAT}
N -1330 -940 -1310 -940 {lab=voPTAT}
N -1330 -1080 -1330 -940 {lab=voPTAT}
N -1330 -750 -1310 -750 {lab=voPTAT}
N -1330 -940 -1330 -750 {lab=voPTAT}
N -1330 -550 -1310 -550 {lab=voPTAT}
N -980 -1080 -640 -1080 {lab=voPTAT}
N -640 -940 -630 -940 {lab=voPTAT}
N -360 -940 -350 -940 {lab=voCTAT}
N -640 -1080 -310 -1080 {lab=voPTAT}
N -310 -940 -300 -940 {lab=voPTAT}
N -30 -940 -20 -940 {lab=voCTAT}
N -1850 -890 -1830 -890 {lab=voCTAT}
N -2150 -1080 -1330 -1080 {lab=voPTAT}
N -1830 -1040 -1020 -1040 {lab=voCTAT}
N -490 -290 -160 -290 {lab=GND}
N -490 -890 -400 -890 {lab=#net32}
N -160 -890 -70 -890 {lab=#net33}
N -490 -890 -490 -840 {lab=#net32}
N -590 -890 -490 -890 {lab=#net32}
N -490 -780 -490 -750 {lab=#net29}
N -490 -750 -490 -720 {lab=#net29}
N -490 -660 -490 -290 {lab=GND}
N -160 -890 -160 -840 {lab=#net33}
N -260 -890 -160 -890 {lab=#net33}
N -160 -750 -160 -730 {lab=#net30}
N -160 -780 -160 -750 {lab=#net30}
N -160 -670 -160 -290 {lab=GND}
N -1830 -890 -1650 -890 {lab=voCTAT}
N -1890 -290 -1750 -290 {lab=GND}
N -2220 -990 -2080 -990 {lab=#net23}
N -2380 -290 -2080 -290 {lab=GND}
N -2520 -990 -2290 -990 {lab=#net23}
N -2520 -550 -2400 -550 {lab=voSCCTP}
N -2520 -590 -2520 -550 {lab=voSCCTP}
N -2400 -550 -2400 -510 {lab=voSCCTP}
N -2400 -510 -2310 -510 {lab=voSCCTP}
N -1660 -650 -1660 -630 {lab=#net34}
N -1660 -570 -1660 -550 {lab=voSCCTN}
N -1890 -570 -1690 -570 {lab=voSCCTN}
N -1890 -600 -1890 -570 {lab=voSCCTN}
N -1690 -570 -1690 -550 {lab=voSCCTN}
N -1690 -550 -1660 -550 {lab=voSCCTN}
N -2920 -290 -2770 -290 {lab=GND}
N -1430 -290 -490 -290 {lab=GND}
N -1430 -990 -1270 -990 {lab=#net23}
N -1650 -890 -1470 -890 {lab=voCTAT}
N -1750 -290 -1430 -290 {lab=GND}
C {sg13g2_pr/sg13_lv_pmos.sym} 1180 -730 0 0 {name=M1
l=0.13u
w=\{wn\}
ng=\{ng\}
m=\{5*m\}
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1660 -730 0 1 {name=M2
l=0.13u
w=\{wn\}
ng=\{ng\}
m=\{5*m\}
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1220 -350 0 1 {name=M3
l=0.13u
w=\{wn\}
ng=\{ng\}
m=\{3*m\}
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1620 -350 0 0 {name=M4
l=0.13u
w=\{wn\}
ng=\{ng\}
m=\{3*m\}
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1340 -800 0 1 {name=M5
l=0.13u
w=9u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1340 -660 2 0 {name=M6
l=0.13u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1500 -800 0 0 {name=M7
l=0.13u
w=9u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1500 -660 2 1 {name=M8
l=0.13u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {vsource.sym} 1120 -520 0 1 {name=Vin value="dc 0 sin 0 \{Vin\} 10meg 0" savecurrent=false}
C {lab_pin.sym} 1120 -570 0 0 {name=p1 sig_type=std_logic lab=Vp}
C {lab_pin.sym} 1120 -470 0 0 {name=p2 sig_type=std_logic lab=Vn}
C {capa.sym} 2540 -560 0 0 {name=C1
m=1
value=\{C1\}
footprint=1206
device="ceramic capacitor"}
C {res.sym} 2620 -560 0 0 {name=R1
value=\{R1\}
footprint=1206
device=resistor
m=1}
C {vsource.sym} 2620 -720 0 0 {name=Vamp_1 value=0 savecurrent=false}
C {lab_pin.sym} 2620 -890 0 1 {name=p3 sig_type=std_logic lab=Vout_1}
C {gnd.sym} 1420 -230 0 0 {name=l3 lab=GND}
C {lab_pin.sym} 680 -780 0 0 {name=p4 sig_type=std_logic lab=Vcomp1}
C {lab_pin.sym} 1330 -730 0 1 {name=p6 sig_type=std_logic lab=Vb1}
C {gnd.sym} 610 -660 0 0 {name=l4 lab=GND}
C {gnd.sym} 910 -660 0 0 {name=l5 lab=GND}
C {code_shown.sym} 2820 -995 0 0 {
name=TT_MODELS
only_toplevel=true
value="
** IHP models
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
"
spice_ignore=false
      }
C {gnd.sym} 2230 -660 0 1 {name=l6 lab=GND}
C {gnd.sym} 1930 -660 0 1 {name=l7 lab=GND}
C {sg13g2_pr/sg13_lv_pmos.sym} 1180 -1050 0 0 {name=M9
l=0.13u
w=\{wn\}
ng=\{ng\}
m=\{5*m\}
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1660 -1050 0 1 {name=M10
l=0.13u
w=\{wn\}
ng=\{ng\}
m=\{5*m\}
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1340 -1120 0 1 {name=M11
l=0.13u
w=9u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1340 -980 2 0 {name=M12
l=0.13u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1500 -1120 0 0 {name=M13
l=0.13u
w=9u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1500 -980 2 1 {name=M14
l=0.13u
w=3u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 680 -1100 0 0 {name=p11 sig_type=std_logic lab=Vcomp2}
C {lab_pin.sym} 1330 -1050 0 1 {name=p14 sig_type=std_logic lab=Vb2}
C {gnd.sym} 610 -980 0 0 {name=l11 lab=GND}
C {gnd.sym} 910 -980 0 0 {name=l12 lab=GND}
C {gnd.sym} 2230 -980 0 1 {name=l14 lab=GND}
C {gnd.sym} 1930 -980 0 1 {name=l15 lab=GND}
C {capa.sym} 2540 -1030 0 0 {name=C2
m=1
value=\{C2\}
footprint=1206
device="ceramic capacitor"}
C {res.sym} 2620 -1030 0 0 {name=R2
value=\{R2\}
footprint=1206
device=resistor
m=1}
C {vsource.sym} 2620 -1130 0 0 {name=Vamp_2 value=0 savecurrent=false}
C {gnd.sym} 2580 -930 0 1 {name=l18 lab=GND}
C {lab_pin.sym} 2620 -1210 0 1 {name=p20 sig_type=std_logic lab=Vout_2}
C {sg13g2_pr/sg13_lv_pmos.sym} 1450 -2010 1 0 {name=M21
l=10u
w=0.5u
ng=1
m=19
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1350 -2010 1 0 {name=M22
l=10u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {gnd.sym} 1260 -1970 0 0 {name=l22 lab=GND}
C {gnd.sym} 1560 -1790 0 0 {name=l25 lab=GND}
C {sg13g2_pr/sg13_lv_pmos.sym} 1450 -1610 1 0 {name=M23
l=10u
w=0.5u
ng=1
m=10
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1350 -1610 1 0 {name=M24
l=10u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {gnd.sym} 1260 -1570 0 0 {name=l26 lab=GND}
C {lab_pin.sym} 2180 -1990 0 1 {name=p27 sig_type=std_logic lab=Vout_1}
C {lab_pin.sym} 1940 -1950 0 1 {name=p28 sig_type=std_logic lab=Vout_2}
C {gnd.sym} 1910 -1630 0 0 {name=l30 lab=GND}
C {lab_pin.sym} 2020 -1690 0 1 {name=p26 sig_type=std_logic lab=S2}
C {gnd.sym} 2140 -1660 0 0 {name=l32 lab=GND}
C {lab_pin.sym} 2230 -1730 0 1 {name=p29 sig_type=std_logic lab=S1}
C {gnd.sym} 770 -650 0 0 {name=l33 lab=GND}
C {lab_pin.sym} 710 -820 0 0 {name=p30 sig_type=std_logic lab=Vout_1}
C {lab_pin.sym} 710 -680 0 0 {name=p31 sig_type=std_logic lab=S1}
C {gnd.sym} 2070 -650 0 1 {name=l34 lab=GND}
C {lab_pin.sym} 2130 -820 0 1 {name=p32 sig_type=std_logic lab=Vout_1}
C {lab_pin.sym} 2130 -680 0 1 {name=p33 sig_type=std_logic lab=S1}
C {gnd.sym} 770 -970 0 0 {name=l35 lab=GND}
C {lab_pin.sym} 710 -1140 0 0 {name=p34 sig_type=std_logic lab=Vout_2}
C {lab_pin.sym} 710 -1000 0 0 {name=p35 sig_type=std_logic lab=S2}
C {gnd.sym} 2070 -970 0 1 {name=l36 lab=GND}
C {lab_pin.sym} 2130 -1000 0 1 {name=p37 sig_type=std_logic lab=S2}
C {lab_pin.sym} 1400 -1890 0 0 {name=p38 sig_type=std_logic lab=Vx1}
C {lab_pin.sym} 1400 -1490 0 0 {name=p39 sig_type=std_logic lab=Vx2}
C {lab_pin.sym} 1740 -1460 0 1 {name=p41 sig_type=std_logic lab=Y}
C {lab_pin.sym} 1740 -1860 0 1 {name=p42 sig_type=std_logic lab=X}
C {lab_pin.sym} 2020 -1790 0 0 {name=p45 sig_type=std_logic lab=S1_p}
C {gnd.sym} 1560 -1390 0 0 {name=l38 lab=GND}
C {lab_pin.sym} 410 -730 0 0 {name=p57 sig_type=std_logic lab=Ibias_1}
C {lab_pin.sym} 2430 -730 0 1 {name=p58 sig_type=std_logic lab=Ibias_2}
C {lab_pin.sym} 2430 -1050 0 1 {name=p59 sig_type=std_logic lab=Ibias_4}
C {lab_pin.sym} 410 -1050 0 0 {name=p60 sig_type=std_logic lab=Ibias_3}
C {lab_pin.sym} 1350 -1790 0 0 {name=p61 sig_type=std_logic lab=Ibias_5}
C {lab_pin.sym} 1350 -1390 0 0 {name=p62 sig_type=std_logic lab=Ibias_6}
C {vsource.sym} 1130 -1170 1 1 {name=Vamp_d2 value=0 savecurrent=false}
C {vsource.sym} 1130 -850 1 1 {name=Vamp_d1 value=0 savecurrent=false}
C {vsource.sym} 910 -1130 0 1 {name=Vamp_buff2 value=0 savecurrent=false}
C {vsource.sym} 910 -810 0 1 {name=Vamp_buff1 value=0 savecurrent=false}
C {/shared/designs/SSDOR_1.2V_v2/components/comp_w_hyst/comp_w_hyst.sym} 1560 -1860 0 0 {name=x25}
C {/shared/designs/SSDOR_1.2V_v2/components/logic_contorller/logic_controller.sym} 1910 -1710 0 0 {name=x15}
C {/shared/designs/SSDOR_1.2V_v2/components/logic_shift_down_v1/logic_shift_down_v1.sym} 2140 -1730 0 0 {name=x17}
C {/shared/designs/SSDOR_1.2V_v2/components/comp_w_hyst/comp_w_hyst.sym} 1560 -1460 0 0 {name=x18}
C {/shared/designs/SSDOR_1.2V_v2/components/mux2_b/mux2_b.sym} 770 -1050 0 0 {name=x8}
C {/shared/designs/SSDOR_1.2V_v2/components/mux2_b/mux2_b.sym} 770 -730 0 0 {name=x1}
C {/shared/designs/SSDOR_1.2V_v2/components/mux2_b/mux2_b.sym} 2070 -1050 0 1 {name=x7}
C {/shared/designs/SSDOR_1.2V_v2/components/mux2_b/mux2_b.sym} 2070 -730 0 1 {name=x14}
C {ammeter.sym} 2380 -1050 1 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {ammeter.sym} 2380 -730 1 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {devices/code_shown.sym} 3140 -980 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib $::SG13G2_MODELS/cornerRES.lib res_typ
"}
C {lab_pin.sym} 1510 -1050 0 0 {name=p51 sig_type=std_logic lab=Vb4}
C {lab_pin.sym} 1510 -730 0 0 {name=p63 sig_type=std_logic lab=Vb3}
C {/shared/designs/SSDOR_1.2V_v2/components/buffer4/buffer4.sym} 840 -970 0 0 {name=x5 wn=5u}
C {/shared/designs/SSDOR_1.2V_v2/components/buffer4/buffer4.sym} 840 -650 0 0 {name=x11 wn=5u}
C {/shared/designs/SSDOR_1.2V_v2/components/buffer4/buffer4.sym} 2000 -650 0 1 {name=x16 wn=5u}
C {/shared/designs/SSDOR_1.2V_v2/components/buffer4/buffer4.sym} 2000 -970 0 1 {name=x20 wn=5u}
C {devices/code_shown.sym} 3130 -910 0 0 {name=MODEL1 only_toplevel=true
format="tcleval( @value )"
value="
.lib $::SG13G2_MODELS/cornerCAP.lib cap_typ
"}
C {/shared/designs/SSDOR_1.2V_v2/components/pmos_comp/pmos_comp.sym} 510 -980 0 0 {name=x4}
C {lab_pin.sym} 1790 -1590 0 0 {name=p12 sig_type=std_logic lab=CLKg}
C {ammeter.sym} 470 -730 3 1 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {ammeter.sym} 460 -1050 3 1 {name=Vmeas3 savecurrent=true spice_ignore=0}
C {gnd.sym} 1440 -1340 0 0 {name=l2 lab=GND}
C {gnd.sym} 1440 -1730 0 0 {name=l9 lab=GND}
C {vsource.sym} 1440 -1760 0 1 {name=Vin1 value=0.4 savecurrent=false}
C {vsource.sym} 1440 -1370 0 1 {name=Vin2 value=0.5 savecurrent=false}
C {lab_pin.sym} 2130 -1140 0 1 {name=p7 sig_type=std_logic lab=Vout_2}
C {vsource.sym} -2290 -1130 0 1 {name=Vamp_id value=0 savecurrent=false}
C {lab_pin.sym} -820 -460 0 1 {name=p24 sig_type=std_logic lab=Ibias_6}
C {lab_pin.sym} -1170 -850 0 1 {name=p8 sig_type=std_logic lab=Ibias_1}
C {lab_pin.sym} -1170 -660 0 1 {name=p10 sig_type=std_logic lab=Ibias_2}
C {lab_pin.sym} -1170 -460 0 1 {name=p13 sig_type=std_logic lab=Ibias_3}
C {lab_pin.sym} -820 -850 0 1 {name=p15 sig_type=std_logic lab=Ibias_4}
C {lab_pin.sym} -820 -670 0 1 {name=p16 sig_type=std_logic lab=Ibias_5}
C {gnd.sym} 510 -1640 0 0 {name=l10 lab=GND}
C {vsource.sym} 510 -1670 0 1 {name=Vin3 value="dc 1" savecurrent=false}
C {gnd.sym} 1880 -1530 0 0 {name=l13 lab=GND}
C {vsource.sym} 1880 -1560 0 1 {name=Vin4 value="PULSE(0 1 0 1n 1n 2.5u 5u)" savecurrent=false}
C {/shared/designs/SSDOR_1.2V_v2/components/startup_ckt/startup_ckt.sym} 2040 -1430 0 0 {name=x9}
C {lab_pin.sym} 2160 -1450 0 1 {name=p9 sig_type=std_logic lab=SEL2}
C {gnd.sym} 2040 -1350 0 0 {name=l8 lab=GND}
C {lab_pin.sym} 1930 -1450 0 0 {name=p43 sig_type=std_logic lab=Vout_2}
C {/shared/designs/SSDOR_1.2V_v2/components/startup_ckt/startup_ckt.sym} 2520 -1420 0 0 {name=x12}
C {lab_pin.sym} 2640 -1440 0 1 {name=p44 sig_type=std_logic lab=SEL1}
C {gnd.sym} 2520 -1340 0 0 {name=l16 lab=GND}
C {lab_pin.sym} 2410 -1440 0 0 {name=p46 sig_type=std_logic lab=Vout_1}
C {/shared/designs/SSDOR_1.2V_v2/components/pmos_comp/pmos_comp.sym} 510 -660 0 0 {name=x6}
C {/shared/designs/SSDOR_1.2V_v2/components/pmos_comp/pmos_comp.sym} 2330 -660 0 1 {name=x13}
C {/shared/designs/SSDOR_1.2V_v2/components/pmos_comp/pmos_comp.sym} 2330 -980 0 1 {name=x3}
C {lab_pin.sym} -2350 -510 3 0 {name=p22 sig_type=std_logic lab=voSCCTP}
C {lab_pin.sym} -1670 -550 3 0 {name=p23 sig_type=std_logic lab=voSCCTN}
C {lab_pin.sym} -1610 -570 3 0 {name=p25 sig_type=std_logic lab=vRCTAT}
C {lab_pin.sym} -2240 -570 3 0 {name=p36 sig_type=std_logic lab=vRPTAT}
C {sg13g2_pr/sg13_lv_pmos.sym} -2100 -890 0 0 {name=M15
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1870 -890 0 1 {name=M16
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -2750 -890 0 1 {name=M17
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -2500 -890 0 1 {name=M18
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1450 -890 0 0 {name=M19
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -2540 -500 0 0 {name=M20
l=1.2u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -2790 -350 0 0 {name=M25
l=1.2u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -2790 -470 0 0 {name=M26
l=0.26u
w=10u
ng=1
m=30
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} -2540 -620 0 0 {name=M27
l=0.26u
w=10u
ng=1
m=30
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1910 -520 0 0 {name=M28
l=360n
w=10u
ng=1
m=20
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1910 -630 0 0 {name=M29
l=360n
w=10u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {/shared/designs/SSDOR_w_startup_1V_ihp/Ib_4u/Ib_4u_opamp/Ib_4u_opamp.sym} -2360 -650 1 1 {name=x10}
C {/shared/designs/SSDOR_w_startup_1V_ihp/Ib_4u/Ib_4u_opamp/Ib_4u_opamp.sym} -1710 -650 1 1 {name=x19}
C {sg13g2_pr/sg13_lv_pmos.sym} -1290 -940 0 0 {name=M30
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1060 -940 0 1 {name=M31
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1290 -750 0 0 {name=M32
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1060 -750 0 1 {name=M33
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1290 -550 0 0 {name=M34
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -1060 -550 0 1 {name=M35
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -940 -550 0 0 {name=M36
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 -550 0 1 {name=M37
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -940 -940 0 0 {name=M38
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 -940 0 1 {name=M39
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -940 -750 0 0 {name=M40
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -710 -750 0 1 {name=M41
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -610 -940 0 0 {name=M42
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -380 -940 0 1 {name=M43
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -280 -940 0 0 {name=M44
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} -50 -940 0 1 {name=M45
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} -2080 -520 0 0 {name=R4
w=0.5e-6
l=1940e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} -1430 -520 0 0 {name=R8
w=0.5e-6
l=1169e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} -1430 -400 0 0 {name=R9
w=0.5e-6
l=27e-6
model=rhigh
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} -490 -810 0 0 {name=R3
w=0.5e-6
l=972.9e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} -490 -690 0 0 {name=R5
w=0.5e-6
l=990e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} -160 -810 0 0 {name=R6
w=0.5e-6
l=1167.4e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} -160 -700 0 0 {name=R7
w=0.5e-6
l=789e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {gnd.sym} -2020 -260 0 0 {name=l1 lab=GND}
C {vsource.sym} -2310 -540 0 1 {name=VprobePTAT value="dc 0 ac 1" savecurrent=false}
C {vsource.sym} -1660 -600 0 1 {name=VprobeCTAT value="dc 0 ac 1" savecurrent=false}
C {lab_pin.sym} -2380 -890 3 0 {name=p18 sig_type=std_logic lab=voPTAT}
C {lab_pin.sym} -1710 -890 3 0 {name=p19 sig_type=std_logic lab=voCTAT}
C {code.sym} 2970 -770 0 1 {name=simulation only_toplevel=false 
value="

* Parameters
.param R1=144
.param R2=180
.param C1=300n
.param C2=300n
.param Vin=1.2
.param wn=5u
.param ng=35
.param m=350

* Data to save
.save all

* Simulation
.control

 set color0 = white

 ac dec 100 1 10e9
 meas ac PM find vp(voPTAT) when vdb(voPTAT)=0
 print PM*180/PI
 setplot PTAT_PM
 plot -vdb(voPTAT) \{vp(voPTAT)*180/PI\}

 meas ac PM find vp(voCTAT) when vdb(voCTAT)=0
 print PM*180/PI
 setplot CTAT_PM
*Estas conectando salida inversora (cambia signo)
 plot -vdb(voCTAT) \{vp(voCTAT)*180/PI\}
  
 reset
 op
 write tb_opamp.raw

.endc

"}
C {lab_pin.sym} 510 -1720 0 1 {name=p17 sig_type=std_logic lab=v1v}
C {lab_pin.sym} -2290 -1190 0 1 {name=p5 sig_type=std_logic lab=Vout_2}
