v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 2920 -1940 2920 -1900 {lab=#net1}
N 2800 -1640 2840 -1640 {lab=GND}
N 2800 -1530 2840 -1530 {lab=GND}
N 2880 -1580 2880 -1560 {lab=#net2}
N 1690 -2000 2130 -2000 {lab=VDD}
N 2060 -1900 2090 -1900 {lab=#net3}
N 2060 -1950 2060 -1900 {lab=#net3}
N 2290 -1950 2290 -1900 {lab=#net3}
N 2740 -1940 2740 -1900 {lab=#net1}
N 1690 -1580 1690 -1540 {lab=#net4}
N 1690 -1630 1790 -1630 {lab=#net5}
N 1790 -1630 1790 -1510 {lab=#net5}
N 1690 -1510 1790 -1510 {lab=#net5}
N 1600 -1630 1650 -1630 {lab=#net6}
N 1600 -1570 1600 -1510 {lab=#net6}
N 1600 -1510 1650 -1510 {lab=#net6}
N 1690 -1680 1690 -1660 {lab=#net6}
N 1560 -1570 1600 -1570 {lab=#net6}
N 1600 -1630 1600 -1570 {lab=#net6}
N 1560 -1680 1560 -1570 {lab=#net6}
N 1560 -1680 1690 -1680 {lab=#net6}
N 1690 -1870 1690 -1680 {lab=#net6}
N 1690 -1580 1900 -1580 {lab=#net4}
N 1690 -1600 1690 -1580 {lab=#net4}
N 1440 -1430 1440 -1390 {lab=#net7}
N 1440 -1480 1540 -1480 {lab=#net5}
N 1540 -1480 1540 -1360 {lab=#net5}
N 1440 -1360 1540 -1360 {lab=#net5}
N 1350 -1480 1400 -1480 {lab=#net8}
N 1350 -1420 1350 -1360 {lab=#net8}
N 1350 -1360 1400 -1360 {lab=#net8}
N 1310 -1420 1350 -1420 {lab=#net8}
N 1350 -1480 1350 -1420 {lab=#net8}
N 1440 -1430 1690 -1430 {lab=#net7}
N 1440 -1450 1440 -1430 {lab=#net7}
N 1690 -1480 1690 -1430 {lab=#net7}
N 1440 -1540 1440 -1510 {lab=#net8}
N 1480 -1950 1770 -1950 {lab=#net3}
N 1770 -1950 1770 -1900 {lab=#net3}
N 1730 -1900 1770 -1900 {lab=#net3}
N 1440 -1340 1440 -1300 {lab=GND}
N 1310 -1540 1310 -1420 {lab=#net8}
N 1310 -1540 1440 -1540 {lab=#net8}
N 1440 -1870 1440 -1540 {lab=#net8}
N 2800 -1640 2800 -1530 {lab=GND}
N 1440 -1300 2130 -1300 {lab=GND}
N 2130 -1580 2130 -1560 {lab=#net9}
N 2130 -1500 2130 -1300 {lab=GND}
N 1920 -1580 2130 -1580 {lab=#net9}
N 2130 -1870 2130 -1580 {lab=#net9}
N 3340 -1870 3340 -1580 {lab=#net10}
N 2880 -1870 2880 -1670 {lab=#net11}
N 2880 -1500 2880 -1300 {lab=GND}
N 2880 -1610 2880 -1580 {lab=#net2}
N 2880 -1300 3340 -1300 {lab=GND}
N 2800 -1300 2880 -1300 {lab=GND}
N 2800 -1530 2800 -1300 {lab=GND}
N 2330 -1870 2330 -1770 {lab=#net12}
N 2700 -1870 2700 -1770 {lab=#net12}
N 2510 -2050 2510 -2000 {lab=VDD}
N 2520 -1300 2800 -1300 {lab=GND}
N 2520 -1300 2520 -690 {lab=GND}
N 2980 -2000 3340 -2000 {lab=VDD}
N 1480 -1950 1480 -1900 {lab=#net3}
N 2060 -1950 2290 -1950 {lab=#net3}
N 2740 -1940 2920 -1940 {lab=#net1}
N 2510 -1770 2700 -1770 {lab=#net12}
N 2920 -1900 3210 -1900 {lab=#net1}
N 1900 -1900 2060 -1900 {lab=#net3}
N 3130 -1580 3340 -1580 {lab=#net10}
N 2880 -1640 2980 -1640 {lab=#net13}
N 2880 -1530 2980 -1530 {lab=#net13}
N 3210 -1900 3300 -1900 {lab=#net1}
N 3340 -1580 3340 -1540 {lab=#net10}
N 3340 -1360 3340 -1300 {lab=GND}
N 3340 -2000 3340 -1930 {lab=VDD}
N 3500 -2000 3500 -1930 {lab=VDD}
N 3460 -2000 3500 -2000 {lab=VDD}
N 3460 -2000 3460 -1900 {lab=VDD}
N 3340 -2000 3460 -2000 {lab=VDD}
N 3500 -1870 3580 -1870 {lab=VDD}
N 3500 -2000 3580 -2000 {lab=VDD}
N 3580 -2000 3580 -1870 {lab=VDD}
N 2510 -1770 2510 -1730 {lab=#net12}
N 2330 -1770 2510 -1770 {lab=#net12}
N 1540 -1360 1540 -1190 {lab=#net5}
N 1540 -1190 1790 -1190 {lab=#net5}
N 1790 -1510 1790 -1190 {lab=#net5}
N 3340 -1480 3340 -1420 {lab=#net14}
N 2310 -1300 2520 -1300 {lab=GND}
N 2330 -2000 2330 -1930 {lab=VDD}
N 2130 -2000 2330 -2000 {lab=VDD}
N 2130 -2000 2130 -1930 {lab=VDD}
N 1690 -2000 1690 -1930 {lab=VDD}
N 1440 -2000 1690 -2000 {lab=VDD}
N 1440 -2000 1440 -1930 {lab=VDD}
N 1300 -1900 1450 -1900 {lab=#net15}
N 1300 -2060 1300 -1900 {lab=#net15}
N 2240 -2060 2390 -2060 {lab=#net15}
N 2390 -2060 2390 -1900 {lab=#net15}
N 2330 -1900 2390 -1900 {lab=#net15}
N 1610 -1900 1690 -1900 {lab=#net15}
N 1610 -2060 1610 -1900 {lab=#net15}
N 1300 -2060 1610 -2060 {lab=#net15}
N 2130 -1900 2240 -1900 {lab=#net15}
N 2240 -2060 2240 -1900 {lab=#net15}
N 1610 -2060 2240 -2060 {lab=#net15}
N 2630 -1900 2710 -1900 {lab=#net15}
N 2630 -2060 2630 -1900 {lab=#net15}
N 3420 -2060 3610 -2060 {lab=#net15}
N 3610 -2060 3610 -1900 {lab=#net15}
N 3500 -1900 3610 -1900 {lab=#net15}
N 3340 -1900 3420 -1900 {lab=#net15}
N 3420 -2060 3420 -1900 {lab=#net15}
N 2820 -2060 3420 -2060 {lab=#net15}
N 2700 -2000 2700 -1930 {lab=VDD}
N 2510 -2000 2700 -2000 {lab=VDD}
N 2880 -2000 2880 -1930 {lab=VDD}
N 2780 -2000 2880 -2000 {lab=VDD}
N 2820 -1900 2890 -1900 {lab=#net15}
N 2820 -2060 2820 -1900 {lab=#net15}
N 2630 -2060 2820 -2060 {lab=#net15}
N 2580 -2060 2630 -2060 {lab=#net15}
N 2330 -2000 2510 -2000 {lab=VDD}
N 1950 -2580 2160 -2580 {lab=#net16}
N 1850 -2500 1950 -2500 {lab=#net16}
N 1850 -2550 1850 -2500 {lab=#net16}
N 1950 -2580 1950 -2500 {lab=#net16}
N 1890 -2580 1950 -2580 {lab=#net16}
N 1850 -2350 1850 -2300 {lab=GND}
N 2060 -2640 2200 -2640 {lab=VDD}
N 1780 -2380 1810 -2380 {lab=#net9}
N 1850 -2500 1850 -2410 {lab=#net16}
N 2050 -2380 2200 -2380 {lab=#net5}
N 1850 -2300 2030 -2300 {lab=GND}
N 2030 -2300 2030 -2180 {lab=GND}
N 1850 -2640 2060 -2640 {lab=VDD}
N 2200 -2480 2200 -2410 {lab=#net3}
N 2200 -2350 2200 -2300 {lab=GND}
N 2200 -2640 2200 -2600 {lab=VDD}
N 1850 -2640 1850 -2610 {lab=VDD}
N 1740 -2580 1860 -2580 {lab=#net17}
N 1740 -2580 1740 -2460 {lab=#net17}
N 1740 -2460 2060 -2460 {lab=#net17}
N 2060 -2480 2060 -2460 {lab=#net17}
N 2060 -2460 2330 -2460 {lab=#net17}
N 2330 -2580 2330 -2460 {lab=#net17}
N 2200 -2580 2330 -2580 {lab=#net17}
N 2060 -2640 2060 -2540 {lab=VDD}
N 2030 -2300 2200 -2300 {lab=GND}
N 1200 -2180 2030 -2180 {lab=GND}
N 1200 -1300 1440 -1300 {lab=GND}
N 1200 -2180 1200 -1300 {lab=GND}
N 1440 -2640 1440 -2000 {lab=VDD}
N 1440 -2640 1850 -2640 {lab=VDD}
N 2200 -2480 2410 -2480 {lab=#net3}
N 2200 -2550 2200 -2480 {lab=#net3}
N 2410 -2480 2410 -2100 {lab=#net3}
N 1900 -2100 2410 -2100 {lab=#net3}
N 1900 -2100 1900 -1900 {lab=#net3}
N 1770 -1900 1900 -1900 {lab=#net3}
N 1900 -1850 1900 -1580 {lab=#net4}
N 1850 -1850 1900 -1850 {lab=#net4}
N 1850 -2130 1850 -1850 {lab=#net4}
N 1850 -2130 2260 -2130 {lab=#net4}
N 2260 -2380 2260 -2130 {lab=#net4}
N 2240 -2380 2260 -2380 {lab=#net4}
N 1920 -1850 1920 -1580 {lab=#net9}
N 1920 -1850 1990 -1850 {lab=#net9}
N 1990 -2230 1990 -1850 {lab=#net9}
N 1780 -2230 1990 -2230 {lab=#net9}
N 1780 -2380 1780 -2230 {lab=#net9}
N 3220 -2520 3430 -2520 {lab=#net18}
N 3120 -2440 3220 -2440 {lab=#net18}
N 3120 -2490 3120 -2440 {lab=#net18}
N 3220 -2520 3220 -2440 {lab=#net18}
N 3160 -2520 3220 -2520 {lab=#net18}
N 3120 -2290 3120 -2240 {lab=GND}
N 3330 -2580 3470 -2580 {lab=VDD}
N 3050 -2320 3080 -2320 {lab=#net10}
N 3120 -2440 3120 -2350 {lab=#net18}
N 3280 -2320 3470 -2320 {lab=#net5}
N 3120 -2240 3300 -2240 {lab=GND}
N 3300 -2240 3300 -2120 {lab=GND}
N 3320 -2580 3330 -2580 {lab=VDD}
N 3470 -2420 3470 -2350 {lab=#net1}
N 3470 -2290 3470 -2240 {lab=GND}
N 3510 -2320 3540 -2320 {lab=#net2}
N 3470 -2580 3470 -2540 {lab=VDD}
N 3120 -2580 3120 -2550 {lab=VDD}
N 3010 -2520 3130 -2520 {lab=#net19}
N 3010 -2520 3010 -2400 {lab=#net19}
N 3010 -2400 3330 -2400 {lab=#net19}
N 3330 -2420 3330 -2400 {lab=#net19}
N 3330 -2400 3600 -2400 {lab=#net19}
N 3600 -2520 3600 -2400 {lab=#net19}
N 3470 -2520 3600 -2520 {lab=#net19}
N 3330 -2580 3330 -2480 {lab=VDD}
N 3300 -2240 3470 -2240 {lab=GND}
N 3300 -2120 3760 -2120 {lab=GND}
N 3340 -1300 3760 -1300 {lab=GND}
N 3760 -2120 3760 -1300 {lab=GND}
N 3580 -2000 3920 -2000 {lab=VDD}
N 3920 -2690 3920 -2000 {lab=VDD}
N 3320 -2690 3920 -2690 {lab=VDD}
N 3320 -2690 3320 -2580 {lab=VDD}
N 3120 -2580 3320 -2580 {lab=VDD}
N 3540 -2320 3540 -2080 {lab=#net2}
N 3050 -2080 3540 -2080 {lab=#net2}
N 3050 -2080 3050 -1580 {lab=#net2}
N 2880 -1580 3050 -1580 {lab=#net2}
N 3470 -2420 3680 -2420 {lab=#net1}
N 3470 -2490 3470 -2420 {lab=#net1}
N 3680 -2420 3680 -2150 {lab=#net1}
N 3210 -2150 3680 -2150 {lab=#net1}
N 3210 -2150 3210 -1900 {lab=#net1}
N 3130 -2160 3130 -1580 {lab=#net10}
N 3050 -2160 3130 -2160 {lab=#net10}
N 3050 -2320 3050 -2160 {lab=#net10}
N 2580 -2140 2660 -2140 {lab=#net15}
N 2580 -2140 2580 -2060 {lab=#net15}
N 2390 -2060 2580 -2060 {lab=#net15}
N 2720 -2140 2780 -2140 {lab=VDD}
N 2780 -2140 2780 -2000 {lab=VDD}
N 2700 -2000 2780 -2000 {lab=VDD}
N 2580 -2220 2660 -2220 {lab=#net15}
N 2580 -2220 2580 -2140 {lab=#net15}
N 2720 -2220 2780 -2220 {lab=VDD}
N 2780 -2220 2780 -2140 {lab=VDD}
N 2980 -1640 2980 -1530 {lab=#net13}
N 2980 -1700 2980 -1640 {lab=#net13}
N 2980 -2000 2980 -1760 {lab=VDD}
N 2880 -2000 2980 -2000 {lab=VDD}
N 2000 -1140 2170 -1140 {lab=#net5}
N 1790 -1190 2000 -1190 {lab=#net5}
N 2000 -1190 2000 -1140 {lab=#net5}
N 1950 -1140 2000 -1140 {lab=#net5}
N 1950 -1080 2310 -1080 {lab=GND}
N 2310 -1300 2310 -1080 {lab=GND}
N 2130 -1300 2310 -1300 {lab=GND}
N 3280 -2370 3280 -2320 {lab=#net5}
N 3120 -2320 3280 -2320 {lab=#net5}
N 2570 -2370 3280 -2370 {lab=#net5}
N 2570 -2370 2570 -2320 {lab=#net5}
N 2050 -2320 2570 -2320 {lab=#net5}
N 2050 -2380 2050 -2320 {lab=#net5}
N 1850 -2380 2050 -2380 {lab=#net5}
N 1090 -2320 2050 -2320 {lab=#net5}
N 1090 -2320 1090 -1190 {lab=#net5}
N 1090 -1190 1540 -1190 {lab=#net5}
N 2660 -850 2660 -820 {lab=#net12}
N 2710 -790 2720 -790 {lab=#net12}
N 2980 -690 4060 -690 {lab=GND}
N 2660 -850 2710 -850 {lab=#net12}
N 2760 -850 2760 -820 {lab=#net20}
N 2860 -920 2930 -920 {lab=#net20}
N 2970 -890 2970 -840 {lab=Ibias_1}
N 2860 -1050 2860 -920 {lab=#net20}
N 2820 -920 2860 -920 {lab=#net20}
N 3720 -890 3720 -840 {lab=Ibias_6}
N 3560 -890 3560 -840 {lab=Ibias_5}
N 3410 -890 3410 -840 {lab=Ibias_4}
N 3270 -890 3270 -840 {lab=Ibias_3}
N 3130 -890 3130 -840 {lab=Ibias_2}
N 4060 -990 4240 -990 {lab=VDD}
N 3680 -1050 3680 -920 {lab=#net20}
N 3520 -1050 3680 -1050 {lab=#net20}
N 3520 -1050 3520 -920 {lab=#net20}
N 3370 -1050 3520 -1050 {lab=#net20}
N 3230 -1050 3230 -920 {lab=#net20}
N 3090 -1050 3230 -1050 {lab=#net20}
N 3090 -1050 3090 -920 {lab=#net20}
N 2760 -850 2820 -850 {lab=#net20}
N 2760 -890 2760 -850 {lab=#net20}
N 2820 -920 2820 -850 {lab=#net20}
N 2800 -920 2820 -920 {lab=#net20}
N 4060 -890 4060 -870 {lab=#net21}
N 4060 -710 4060 -690 {lab=GND}
N 4060 -790 4060 -770 {lab=Vb_0v5}
N 4060 -790 4090 -790 {lab=Vb_0v5}
N 4060 -810 4060 -790 {lab=Vb_0v5}
N 4240 -890 4240 -870 {lab=#net22}
N 4240 -790 4240 -770 {lab=Vb_0v4}
N 4060 -690 4240 -690 {lab=GND}
N 4240 -710 4240 -690 {lab=GND}
N 4240 -790 4290 -790 {lab=Vb_0v4}
N 4240 -810 4240 -790 {lab=Vb_0v4}
N 3680 -1050 4020 -1050 {lab=#net20}
N 4020 -1050 4020 -920 {lab=#net20}
N 4020 -1050 4200 -1050 {lab=#net20}
N 4200 -1050 4200 -920 {lab=#net20}
N 2860 -1050 3090 -1050 {lab=#net20}
N 2710 -850 2710 -790 {lab=#net12}
N 2700 -790 2710 -790 {lab=#net12}
N 2710 -790 2710 -750 {lab=#net12}
N 4240 -990 4240 -950 {lab=VDD}
N 4060 -990 4060 -950 {lab=VDD}
N 3720 -990 4060 -990 {lab=VDD}
N 3720 -990 3720 -950 {lab=VDD}
N 3560 -990 3720 -990 {lab=VDD}
N 3560 -990 3560 -950 {lab=VDD}
N 3410 -990 3560 -990 {lab=VDD}
N 3410 -990 3410 -940 {lab=VDD}
N 3270 -990 3410 -990 {lab=VDD}
N 3270 -990 3270 -950 {lab=VDD}
N 3130 -990 3270 -990 {lab=VDD}
N 3130 -990 3130 -950 {lab=VDD}
N 2970 -990 3130 -990 {lab=VDD}
N 2970 -990 2970 -950 {lab=VDD}
N 2760 -990 2970 -990 {lab=VDD}
N 2970 -920 3060 -920 {lab=#net23}
N 3060 -920 3060 -640 {lab=#net23}
N 3130 -920 3200 -920 {lab=#net23}
N 3200 -920 3200 -640 {lab=#net23}
N 3060 -640 3200 -640 {lab=#net23}
N 3270 -920 3330 -920 {lab=#net23}
N 3330 -920 3330 -640 {lab=#net23}
N 3200 -640 3330 -640 {lab=#net23}
N 3490 -910 3490 -640 {lab=#net23}
N 3330 -640 3490 -640 {lab=#net23}
N 3560 -920 3620 -920 {lab=#net23}
N 3620 -920 3620 -640 {lab=#net23}
N 3490 -640 3620 -640 {lab=#net23}
N 3720 -920 3820 -920 {lab=#net23}
N 3820 -920 3820 -640 {lab=#net23}
N 3620 -640 3820 -640 {lab=#net23}
N 4060 -920 4150 -920 {lab=#net23}
N 4150 -920 4150 -640 {lab=#net23}
N 3820 -640 4150 -640 {lab=#net23}
N 4340 -920 4340 -640 {lab=#net23}
N 4150 -640 4340 -640 {lab=#net23}
N 4240 -920 4340 -920 {lab=#net23}
N 4800 -700 5110 -700 {lab=VDD}
N 4340 -640 5110 -640 {lab=#net23}
N 4800 -990 4800 -700 {lab=VDD}
N 4440 -700 4800 -700 {lab=VDD}
N 4240 -990 4800 -990 {lab=VDD}
N 2660 -760 2660 -690 {lab=GND}
N 2760 -990 2760 -950 {lab=VDD}
N 2440 -920 2760 -920 {lab=#net23}
N 2440 -920 2440 -640 {lab=#net23}
N 2440 -640 3060 -640 {lab=#net23}
N 2550 -790 2660 -790 {lab=#net24}
N 2550 -790 2550 -580 {lab=#net24}
N 2870 -790 2870 -580 {lab=#net24}
N 2760 -790 2870 -790 {lab=#net24}
N 2870 -580 2920 -580 {lab=#net24}
N 2980 -690 2980 -580 {lab=GND}
N 2760 -690 2980 -690 {lab=GND}
N 3410 -910 3490 -910 {lab=#net23}
N 3370 -1050 3370 -910 {lab=#net20}
N 3230 -1050 3370 -1050 {lab=#net20}
N 2760 -760 2760 -690 {lab=GND}
N 2660 -690 2760 -690 {lab=GND}
N 2520 -690 2660 -690 {lab=GND}
N 2340 -690 2520 -690 {lab=GND}
N 2510 -1730 2660 -1730 {lab=#net12}
N 2660 -1730 2660 -850 {lab=#net12}
N 3920 -2000 3920 -1160 {lab=VDD}
N 2760 -1160 3920 -1160 {lab=VDD}
N 2760 -1160 2760 -990 {lab=VDD}
N 2550 -580 2870 -580 {lab=#net24}
N 1790 -580 2550 -580 {lab=#net24}
N 1790 -1190 1790 -580 {lab=#net5}
C {iopin.sym} 2510 -2050 0 0 {name=p1 lab=VDD}
C {sg13g2_pr/sg13_lv_pmos.sym} 2110 -1900 0 0 {name=M1
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2310 -1900 0 0 {name=M2
l=2u
w=1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2720 -1900 0 1 {name=M3
l=2u
w=1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2900 -1900 0 1 {name=M4
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1460 -1900 0 1 {name=M12
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1710 -1900 0 1 {name=M13
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3320 -1900 0 0 {name=M5
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1670 -1510 0 0 {name=M7
l=1.2u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1420 -1360 0 0 {name=M10
l=1.2u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1420 -1480 0 0 {name=M11
l=0.26u
w=10u
ng=1
m=30
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1670 -1630 0 0 {name=M16
l=0.26u
w=10u
ng=1
m=30
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2860 -1530 0 0 {name=M24
l=0.36u
w=10u
ng=1
m=20
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2860 -1640 0 0 {name=M25
l=0.36u
w=10u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 3340 -1510 0 0 {name=R1
w=0.5e-6
l=1170e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 3340 -1390 0 0 {name=R3
w=0.5e-6
l=27e-6
model=rhigh
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 2130 -1530 0 0 {name=R10
w=0.5e-6
l=2110e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3480 -1900 0 0 {name=M6
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1830 -2380 0 0 {name=M8
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1870 -2580 0 1 {name=M9
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2180 -2580 0 0 {name=M14
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -2380 0 1 {name=M15
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/ntap1.sym} 2060 -2510 0 1 {name=R2
model=ntap1
spiceprefix=X
w=1e-6
l=20e-6
}
C {sg13g2_pr/ptap1.sym} 1950 -1110 2 0 {name=R4_opamp
model=ptap1
spiceprefix=X
w=56e-6
l=1e-6
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3100 -2320 0 0 {name=M17
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3140 -2520 0 1 {name=M18
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3450 -2520 0 0 {name=M19
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3490 -2320 0 1 {name=M20
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/ntap1.sym} 3330 -2450 0 1 {name=R5
model=ntap1
spiceprefix=X
w=1e-6
l=20e-6
}
C {sg13g2_pr/ptap1.sym} 2170 -1110 2 0 {name=R6_opamp
model=ptap1
spiceprefix=X
w=56e-6
l=1e-6
}
C {sg13g2_pr/ntap1.sym} 2690 -2140 1 0 {name=R7
model=ntap1
spiceprefix=X
w=5e-6
l=1e-6
}
C {sg13g2_pr/ntap1.sym} 2690 -2220 1 0 {name=R8
model=ntap1
spiceprefix=X
w=5e-6
l=1e-6
}
C {sg13g2_pr/ntap1.sym} 2980 -1730 0 1 {name=R9
model=ntap1
spiceprefix=X
w=1e-6
l=8e-6
}
C {sg13g2_pr/ptap1.sym} 2050 -1110 2 0 {name=R11_PTAT
model=ptap1
spiceprefix=X
w=1e-6
l=19e-6
}
C {iopin.sym} 2970 -840 0 0 {name=p4 lab=Ibias_1}
C {iopin.sym} 3130 -840 0 0 {name=p5 lab=Ibias_2}
C {iopin.sym} 3270 -840 0 0 {name=p6 lab=Ibias_3}
C {iopin.sym} 3410 -840 0 0 {name=p7 lab=Ibias_4}
C {iopin.sym} 3560 -840 0 0 {name=p8 lab=Ibias_5}
C {iopin.sym} 3720 -840 0 0 {name=p9 lab=Ibias_6}
C {sg13g2_pr/sg13_lv_nmos.sym} 2680 -790 0 1 {name=M30
l=2u
w=1.1u
ng=1
m=3
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 4060 -840 0 0 {name=R4
w=0.5e-6
l=972.9e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 4240 -840 0 0 {name=R6
w=0.5e-6
l=1167.4e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {iopin.sym} 4290 -790 0 0 {name=p16 lab=Vb_0v4}
C {iopin.sym} 4090 -790 0 0 {name=p17 lab=Vb_0v5}
C {sg13g2_pr/sg13_lv_nmos.sym} 2740 -790 0 0 {name=M21
l=2u
w=1.1u
ng=1
m=3
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2780 -920 0 1 {name=M23
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2950 -920 0 0 {name=M22
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3110 -920 0 0 {name=M26
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3250 -920 0 0 {name=M27
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3390 -910 0 0 {name=M28
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3540 -920 0 0 {name=M29
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3700 -920 0 0 {name=M31
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/cap_cmim.sym} 2710 -720 0 0 {name=C5
model=cap_cmim
w=18e-6
l=18e-6
m=9
spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 2910 -1020 0 0 {name=C2
model=cap_cmim
w=2.6e-6
l=2.6e-6
m=1
spiceprefix=X}
C {iopin.sym} 2340 -690 0 1 {name=p10 lab=GND}
C {sg13g2_pr/ntap1.sym} 4440 -670 0 0 {name=R11
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4510 -670 0 0 {name=R12
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4610 -670 0 0 {name=R13
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4680 -670 0 0 {name=R14
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4770 -670 0 0 {name=R15
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4840 -670 0 0 {name=R16
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4940 -670 0 0 {name=R17
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 5010 -670 0 0 {name=R18
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 5110 -670 0 0 {name=R19
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ptap1.sym} 2950 -580 1 0 {name=R20
model=ptap1
spiceprefix=X
w=1e-6
l=5e-6
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4040 -920 0 0 {name=M32
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 4220 -920 0 0 {name=M33
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 4060 -740 0 0 {name=R21
w=0.5e-6
l=994e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 4240 -740 0 0 {name=R22
w=0.5e-6
l=792e-6
model=rppd
body=GND
spiceprefix=X
b=0
m=1
}
