v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 5680 -1330 {}
N 2590 -1820 2590 -1780 {lab=#net1}
N 2470 -1520 2510 -1520 {lab=VSS}
N 2470 -1410 2510 -1410 {lab=VSS}
N 2550 -1460 2550 -1440 {lab=#net2}
N 1360 -1880 1800 -1880 {lab=Vout_2}
N 1730 -1780 1760 -1780 {lab=#net3}
N 1730 -1830 1730 -1780 {lab=#net3}
N 1960 -1830 1960 -1780 {lab=#net3}
N 2410 -1820 2410 -1780 {lab=#net1}
N 1360 -1460 1360 -1420 {lab=#net4}
N 1360 -1510 1460 -1510 {lab=pt_well}
N 1460 -1510 1460 -1390 {lab=pt_well}
N 1360 -1390 1460 -1390 {lab=pt_well}
N 1270 -1510 1320 -1510 {lab=#net5}
N 1270 -1450 1270 -1390 {lab=#net5}
N 1270 -1390 1320 -1390 {lab=#net5}
N 1360 -1560 1360 -1540 {lab=#net5}
N 1230 -1450 1270 -1450 {lab=#net5}
N 1270 -1510 1270 -1450 {lab=#net5}
N 1230 -1560 1230 -1450 {lab=#net5}
N 1230 -1560 1360 -1560 {lab=#net5}
N 1360 -1750 1360 -1560 {lab=#net5}
N 1360 -1460 1570 -1460 {lab=#net4}
N 1360 -1480 1360 -1460 {lab=#net4}
N 1110 -1310 1110 -1270 {lab=#net6}
N 1110 -1360 1210 -1360 {lab=pt_well}
N 1210 -1360 1210 -1240 {lab=pt_well}
N 1110 -1240 1210 -1240 {lab=pt_well}
N 1020 -1360 1070 -1360 {lab=#net7}
N 1020 -1300 1020 -1240 {lab=#net7}
N 1020 -1240 1070 -1240 {lab=#net7}
N 980 -1300 1020 -1300 {lab=#net7}
N 1020 -1360 1020 -1300 {lab=#net7}
N 1110 -1310 1360 -1310 {lab=#net6}
N 1110 -1330 1110 -1310 {lab=#net6}
N 1360 -1360 1360 -1310 {lab=#net6}
N 1110 -1420 1110 -1390 {lab=#net7}
N 1150 -1830 1440 -1830 {lab=#net3}
N 1440 -1830 1440 -1780 {lab=#net3}
N 1400 -1780 1440 -1780 {lab=#net3}
N 1110 -1220 1110 -1180 {lab=VSS}
N 980 -1420 980 -1300 {lab=#net7}
N 980 -1420 1110 -1420 {lab=#net7}
N 1110 -1750 1110 -1420 {lab=#net7}
N 2470 -1520 2470 -1410 {lab=VSS}
N 1110 -1180 1800 -1180 {lab=VSS}
N 1800 -1460 1800 -1440 {lab=#net8}
N 1800 -1380 1800 -1180 {lab=VSS}
N 1590 -1460 1800 -1460 {lab=#net8}
N 1800 -1750 1800 -1460 {lab=#net8}
N 3010 -1750 3010 -1460 {lab=#net9}
N 2550 -1750 2550 -1550 {lab=#net10}
N 2550 -1380 2550 -1180 {lab=VSS}
N 2550 -1490 2550 -1460 {lab=#net2}
N 2550 -1180 3010 -1180 {lab=VSS}
N 2470 -1180 2550 -1180 {lab=VSS}
N 2470 -1410 2470 -1180 {lab=VSS}
N 2000 -1750 2000 -1650 {lab=#net11}
N 2370 -1750 2370 -1650 {lab=#net11}
N 2180 -1930 2180 -1880 {lab=Vout_2}
N 2190 -1180 2470 -1180 {lab=VSS}
N 2190 -1180 2190 -570 {lab=VSS}
N 2650 -1880 3010 -1880 {lab=Vout_2}
N 1150 -1830 1150 -1780 {lab=#net3}
N 1730 -1830 1960 -1830 {lab=#net3}
N 2410 -1820 2590 -1820 {lab=#net1}
N 2180 -1650 2370 -1650 {lab=#net11}
N 2590 -1780 2880 -1780 {lab=#net1}
N 1570 -1780 1730 -1780 {lab=#net3}
N 2800 -1460 3010 -1460 {lab=#net9}
N 2550 -1520 2650 -1520 {lab=#net12}
N 2550 -1410 2650 -1410 {lab=#net12}
N 2880 -1780 2970 -1780 {lab=#net1}
N 3010 -1460 3010 -1420 {lab=#net9}
N 3010 -1240 3010 -1180 {lab=VSS}
N 3010 -1880 3010 -1810 {lab=Vout_2}
N 3170 -1880 3170 -1810 {lab=Vout_2}
N 3130 -1880 3170 -1880 {lab=Vout_2}
N 3130 -1880 3130 -1780 {lab=Vout_2}
N 3010 -1880 3130 -1880 {lab=Vout_2}
N 3170 -1750 3250 -1750 {lab=Vout_2}
N 3170 -1880 3250 -1880 {lab=Vout_2}
N 3250 -1880 3250 -1750 {lab=Vout_2}
N 2180 -1650 2180 -1610 {lab=#net11}
N 2000 -1650 2180 -1650 {lab=#net11}
N 1210 -1240 1210 -1070 {lab=pt_well}
N 1210 -1070 1460 -1070 {lab=pt_well}
N 1460 -1390 1460 -1070 {lab=pt_well}
N 3010 -1360 3010 -1300 {lab=#net13}
N 1980 -1180 2190 -1180 {lab=VSS}
N 2000 -1880 2000 -1810 {lab=Vout_2}
N 1800 -1880 2000 -1880 {lab=Vout_2}
N 1800 -1880 1800 -1810 {lab=Vout_2}
N 1360 -1880 1360 -1810 {lab=Vout_2}
N 1110 -1880 1360 -1880 {lab=Vout_2}
N 1110 -1880 1110 -1810 {lab=Vout_2}
N 970 -1780 1120 -1780 {lab=#net14}
N 970 -1940 970 -1780 {lab=#net14}
N 1910 -1940 2060 -1940 {lab=#net14}
N 2060 -1940 2060 -1780 {lab=#net14}
N 2000 -1780 2060 -1780 {lab=#net14}
N 1280 -1780 1360 -1780 {lab=#net14}
N 1280 -1940 1280 -1780 {lab=#net14}
N 970 -1940 1280 -1940 {lab=#net14}
N 1800 -1780 1910 -1780 {lab=#net14}
N 1910 -1940 1910 -1780 {lab=#net14}
N 1280 -1940 1910 -1940 {lab=#net14}
N 2300 -1780 2380 -1780 {lab=#net14}
N 2300 -1940 2300 -1780 {lab=#net14}
N 3090 -1940 3280 -1940 {lab=#net14}
N 3280 -1940 3280 -1780 {lab=#net14}
N 3170 -1780 3280 -1780 {lab=#net14}
N 3010 -1780 3090 -1780 {lab=#net14}
N 3090 -1940 3090 -1780 {lab=#net14}
N 2490 -1940 3090 -1940 {lab=#net14}
N 2370 -1880 2370 -1810 {lab=Vout_2}
N 2180 -1880 2370 -1880 {lab=Vout_2}
N 2550 -1880 2550 -1810 {lab=Vout_2}
N 2450 -1880 2550 -1880 {lab=Vout_2}
N 2490 -1780 2560 -1780 {lab=#net14}
N 2490 -1940 2490 -1780 {lab=#net14}
N 2300 -1940 2490 -1940 {lab=#net14}
N 2250 -1940 2300 -1940 {lab=#net14}
N 2000 -1880 2180 -1880 {lab=Vout_2}
N 1620 -2460 1830 -2460 {lab=#net15}
N 1520 -2380 1620 -2380 {lab=#net15}
N 1520 -2430 1520 -2380 {lab=#net15}
N 1620 -2460 1620 -2380 {lab=#net15}
N 1560 -2460 1620 -2460 {lab=#net15}
N 1520 -2230 1520 -2180 {lab=VSS}
N 1730 -2520 1870 -2520 {lab=Vout_2}
N 1450 -2260 1480 -2260 {lab=#net8}
N 1520 -2380 1520 -2290 {lab=#net15}
N 1720 -2260 1870 -2260 {lab=pt_well}
N 1520 -2180 1700 -2180 {lab=VSS}
N 1700 -2180 1700 -2060 {lab=VSS}
N 1520 -2520 1730 -2520 {lab=Vout_2}
N 1870 -2360 1870 -2290 {lab=#net3}
N 1870 -2230 1870 -2180 {lab=VSS}
N 1870 -2520 1870 -2480 {lab=Vout_2}
N 1520 -2520 1520 -2490 {lab=Vout_2}
N 1410 -2460 1530 -2460 {lab=#net16}
N 1410 -2460 1410 -2340 {lab=#net16}
N 1410 -2340 1730 -2340 {lab=#net16}
N 1730 -2360 1730 -2340 {lab=#net16}
N 1730 -2340 2000 -2340 {lab=#net16}
N 2000 -2460 2000 -2340 {lab=#net16}
N 1870 -2460 2000 -2460 {lab=#net16}
N 1730 -2520 1730 -2420 {lab=Vout_2}
N 1700 -2180 1870 -2180 {lab=VSS}
N 870 -2060 1700 -2060 {lab=VSS}
N 870 -1180 1110 -1180 {lab=VSS}
N 870 -2060 870 -1180 {lab=VSS}
N 1110 -2520 1110 -1880 {lab=Vout_2}
N 1110 -2520 1520 -2520 {lab=Vout_2}
N 1870 -2360 2080 -2360 {lab=#net3}
N 1870 -2430 1870 -2360 {lab=#net3}
N 2080 -2360 2080 -1980 {lab=#net3}
N 1570 -1980 2080 -1980 {lab=#net3}
N 1570 -1980 1570 -1780 {lab=#net3}
N 1440 -1780 1570 -1780 {lab=#net3}
N 1570 -1730 1570 -1460 {lab=#net4}
N 1520 -1730 1570 -1730 {lab=#net4}
N 1520 -2010 1520 -1730 {lab=#net4}
N 1520 -2010 1930 -2010 {lab=#net4}
N 1930 -2260 1930 -2010 {lab=#net4}
N 1910 -2260 1930 -2260 {lab=#net4}
N 1590 -1730 1590 -1460 {lab=#net8}
N 1590 -1730 1660 -1730 {lab=#net8}
N 1660 -2110 1660 -1730 {lab=#net8}
N 1450 -2110 1660 -2110 {lab=#net8}
N 1450 -2260 1450 -2110 {lab=#net8}
N 2890 -2400 3100 -2400 {lab=#net17}
N 2790 -2320 2890 -2320 {lab=#net17}
N 2790 -2370 2790 -2320 {lab=#net17}
N 2890 -2400 2890 -2320 {lab=#net17}
N 2830 -2400 2890 -2400 {lab=#net17}
N 2790 -2170 2790 -2120 {lab=VSS}
N 3000 -2460 3140 -2460 {lab=Vout_2}
N 2720 -2200 2750 -2200 {lab=#net9}
N 2790 -2320 2790 -2230 {lab=#net17}
N 2950 -2200 3140 -2200 {lab=pt_well}
N 2790 -2120 2970 -2120 {lab=VSS}
N 2970 -2120 2970 -2000 {lab=VSS}
N 2990 -2460 3000 -2460 {lab=Vout_2}
N 3140 -2300 3140 -2230 {lab=#net1}
N 3140 -2170 3140 -2120 {lab=VSS}
N 3180 -2200 3210 -2200 {lab=#net2}
N 3140 -2460 3140 -2420 {lab=Vout_2}
N 2790 -2460 2790 -2430 {lab=Vout_2}
N 2680 -2400 2800 -2400 {lab=#net18}
N 2680 -2400 2680 -2280 {lab=#net18}
N 2680 -2280 3000 -2280 {lab=#net18}
N 3000 -2300 3000 -2280 {lab=#net18}
N 3000 -2280 3270 -2280 {lab=#net18}
N 3270 -2400 3270 -2280 {lab=#net18}
N 3140 -2400 3270 -2400 {lab=#net18}
N 3000 -2460 3000 -2360 {lab=Vout_2}
N 2970 -2120 3140 -2120 {lab=VSS}
N 2970 -2000 3430 -2000 {lab=VSS}
N 3010 -1180 3430 -1180 {lab=VSS}
N 3430 -2000 3430 -1180 {lab=VSS}
N 3250 -1880 3590 -1880 {lab=Vout_2}
N 3590 -2570 3590 -1880 {lab=Vout_2}
N 2990 -2570 3590 -2570 {lab=Vout_2}
N 2990 -2570 2990 -2460 {lab=Vout_2}
N 2790 -2460 2990 -2460 {lab=Vout_2}
N 3210 -2200 3210 -1960 {lab=#net2}
N 2720 -1960 3210 -1960 {lab=#net2}
N 2720 -1960 2720 -1460 {lab=#net2}
N 2550 -1460 2720 -1460 {lab=#net2}
N 3140 -2300 3350 -2300 {lab=#net1}
N 3140 -2370 3140 -2300 {lab=#net1}
N 3350 -2300 3350 -2030 {lab=#net1}
N 2880 -2030 3350 -2030 {lab=#net1}
N 2880 -2030 2880 -1780 {lab=#net1}
N 2800 -2040 2800 -1460 {lab=#net9}
N 2720 -2040 2800 -2040 {lab=#net9}
N 2720 -2200 2720 -2040 {lab=#net9}
N 2250 -2020 2330 -2020 {lab=#net14}
N 2250 -2020 2250 -1940 {lab=#net14}
N 2060 -1940 2250 -1940 {lab=#net14}
N 2390 -2020 2450 -2020 {lab=Vout_2}
N 2450 -2020 2450 -1880 {lab=Vout_2}
N 2370 -1880 2450 -1880 {lab=Vout_2}
N 2250 -2100 2330 -2100 {lab=#net14}
N 2250 -2100 2250 -2020 {lab=#net14}
N 2390 -2100 2450 -2100 {lab=Vout_2}
N 2450 -2100 2450 -2020 {lab=Vout_2}
N 2650 -1520 2650 -1410 {lab=#net12}
N 2650 -1580 2650 -1520 {lab=#net12}
N 2650 -1880 2650 -1640 {lab=Vout_2}
N 2550 -1880 2650 -1880 {lab=Vout_2}
N 1720 -1070 1840 -1070 {lab=pt_well}
N 1840 -930 1980 -930 {lab=VSS}
N 1980 -1180 1980 -930 {lab=VSS}
N 1800 -1180 1980 -1180 {lab=VSS}
N 2950 -2250 2950 -2200 {lab=pt_well}
N 2790 -2200 2950 -2200 {lab=pt_well}
N 2240 -2250 2950 -2250 {lab=pt_well}
N 2240 -2250 2240 -2200 {lab=pt_well}
N 1720 -2200 2240 -2200 {lab=pt_well}
N 1720 -2260 1720 -2200 {lab=pt_well}
N 1520 -2260 1720 -2260 {lab=pt_well}
N 760 -2200 1720 -2200 {lab=pt_well}
N 760 -2200 760 -1070 {lab=pt_well}
N 760 -1070 1210 -1070 {lab=pt_well}
N 2330 -730 2330 -700 {lab=#net11}
N 2380 -670 2390 -670 {lab=#net11}
N 2650 -570 3730 -570 {lab=VSS}
N 2330 -730 2380 -730 {lab=#net11}
N 2430 -730 2430 -700 {lab=#net19}
N 2530 -800 2600 -800 {lab=#net19}
N 2640 -770 2640 -720 {lab=Ibias_1}
N 2530 -930 2530 -800 {lab=#net19}
N 2490 -800 2530 -800 {lab=#net19}
N 3390 -770 3390 -720 {lab=Ibias_6}
N 3230 -770 3230 -720 {lab=Ibias_5}
N 3080 -770 3080 -720 {lab=Ibias_4}
N 2940 -770 2940 -720 {lab=Ibias_3}
N 2800 -770 2800 -720 {lab=Ibias_2}
N 3730 -870 3910 -870 {lab=Vout_2}
N 3350 -930 3350 -800 {lab=#net19}
N 3190 -930 3350 -930 {lab=#net19}
N 3190 -930 3190 -800 {lab=#net19}
N 3040 -930 3190 -930 {lab=#net19}
N 2900 -930 2900 -800 {lab=#net19}
N 2760 -930 2900 -930 {lab=#net19}
N 2760 -930 2760 -800 {lab=#net19}
N 2430 -730 2490 -730 {lab=#net19}
N 2430 -770 2430 -730 {lab=#net19}
N 2490 -800 2490 -730 {lab=#net19}
N 2470 -800 2490 -800 {lab=#net19}
N 3730 -770 3730 -750 {lab=#net20}
N 3730 -590 3730 -570 {lab=VSS}
N 3730 -670 3730 -650 {lab=Vb0v5}
N 3730 -670 3760 -670 {lab=Vb0v5}
N 3730 -690 3730 -670 {lab=Vb0v5}
N 3910 -770 3910 -750 {lab=#net21}
N 3910 -670 3910 -650 {lab=Vb0v4}
N 3730 -570 3910 -570 {lab=VSS}
N 3910 -590 3910 -570 {lab=VSS}
N 3910 -670 3960 -670 {lab=Vb0v4}
N 3910 -690 3910 -670 {lab=Vb0v4}
N 3350 -930 3690 -930 {lab=#net19}
N 3690 -930 3690 -800 {lab=#net19}
N 3690 -930 3870 -930 {lab=#net19}
N 3870 -930 3870 -800 {lab=#net19}
N 2530 -930 2760 -930 {lab=#net19}
N 2380 -730 2380 -670 {lab=#net11}
N 2370 -670 2380 -670 {lab=#net11}
N 2380 -670 2380 -630 {lab=#net11}
N 3910 -870 3910 -830 {lab=Vout_2}
N 3730 -870 3730 -830 {lab=Vout_2}
N 3390 -870 3730 -870 {lab=Vout_2}
N 3390 -870 3390 -830 {lab=Vout_2}
N 3230 -870 3390 -870 {lab=Vout_2}
N 3230 -870 3230 -830 {lab=Vout_2}
N 3080 -870 3230 -870 {lab=Vout_2}
N 3080 -870 3080 -820 {lab=Vout_2}
N 2940 -870 3080 -870 {lab=Vout_2}
N 2940 -870 2940 -830 {lab=Vout_2}
N 2800 -870 2940 -870 {lab=Vout_2}
N 2800 -870 2800 -830 {lab=Vout_2}
N 2640 -870 2800 -870 {lab=Vout_2}
N 2640 -870 2640 -830 {lab=Vout_2}
N 2430 -870 2640 -870 {lab=Vout_2}
N 2640 -800 2730 -800 {lab=#net22}
N 2730 -800 2730 -520 {lab=#net22}
N 2800 -800 2870 -800 {lab=#net22}
N 2870 -800 2870 -520 {lab=#net22}
N 2730 -520 2870 -520 {lab=#net22}
N 2940 -800 3000 -800 {lab=#net22}
N 3000 -800 3000 -520 {lab=#net22}
N 2870 -520 3000 -520 {lab=#net22}
N 3160 -790 3160 -520 {lab=#net22}
N 3000 -520 3160 -520 {lab=#net22}
N 3230 -800 3290 -800 {lab=#net22}
N 3290 -800 3290 -520 {lab=#net22}
N 3160 -520 3290 -520 {lab=#net22}
N 3390 -800 3490 -800 {lab=#net22}
N 3490 -800 3490 -520 {lab=#net22}
N 3290 -520 3490 -520 {lab=#net22}
N 3730 -800 3820 -800 {lab=#net22}
N 3820 -800 3820 -520 {lab=#net22}
N 3490 -520 3820 -520 {lab=#net22}
N 4010 -800 4010 -520 {lab=#net22}
N 3820 -520 4010 -520 {lab=#net22}
N 3910 -800 4010 -800 {lab=#net22}
N 4470 -580 4780 -580 {lab=Vout_2}
N 4010 -520 4780 -520 {lab=#net22}
N 4470 -870 4470 -580 {lab=Vout_2}
N 4110 -580 4470 -580 {lab=Vout_2}
N 3910 -870 4470 -870 {lab=Vout_2}
N 2330 -640 2330 -570 {lab=VSS}
N 2430 -870 2430 -830 {lab=Vout_2}
N 2110 -800 2430 -800 {lab=#net22}
N 2110 -800 2110 -520 {lab=#net22}
N 2110 -520 2730 -520 {lab=#net22}
N 2220 -670 2330 -670 {lab=pt_well}
N 2220 -670 2220 -460 {lab=pt_well}
N 2540 -670 2540 -460 {lab=pt_well}
N 2430 -670 2540 -670 {lab=pt_well}
N 2540 -460 2590 -460 {lab=pt_well}
N 2650 -570 2650 -460 {lab=VSS}
N 2430 -570 2650 -570 {lab=VSS}
N 3080 -790 3160 -790 {lab=#net22}
N 3040 -930 3040 -790 {lab=#net19}
N 2900 -930 3040 -930 {lab=#net19}
N 2430 -640 2430 -570 {lab=VSS}
N 2330 -570 2430 -570 {lab=VSS}
N 2190 -570 2330 -570 {lab=VSS}
N 2010 -570 2190 -570 {lab=VSS}
N 2180 -1610 2330 -1610 {lab=#net11}
N 2330 -1610 2330 -730 {lab=#net11}
N 3590 -1880 3590 -1040 {lab=Vout_2}
N 2430 -1040 3590 -1040 {lab=Vout_2}
N 2430 -1040 2430 -870 {lab=Vout_2}
N 1460 -460 2220 -460 {lab=pt_well}
N 1460 -1070 1460 -460 {lab=pt_well}
N 6210 -1690 6230 -1690 {lab=#net23}
N 6510 -1690 6530 -1690 {lab=#net24}
N 6270 -1570 6450 -1630 {lab=#net23}
N 6150 -1570 6270 -1570 {lab=#net23}
N 6270 -1630 6450 -1570 {lab=#net24}
N 6450 -1570 6570 -1570 {lab=#net24}
N 6150 -1570 6150 -1480 {lab=#net23}
N 6150 -1630 6150 -1570 {lab=#net23}
N 6270 -1660 6270 -1630 {lab=#net24}
N 6450 -1660 6450 -1630 {lab=#net23}
N 6570 -1570 6570 -1480 {lab=#net24}
N 6570 -1630 6570 -1570 {lab=#net24}
N 6210 -1690 6210 -1630 {lab=#net23}
N 6190 -1690 6210 -1690 {lab=#net23}
N 6150 -1630 6210 -1630 {lab=#net23}
N 6150 -1660 6150 -1630 {lab=#net23}
N 6510 -1690 6510 -1630 {lab=#net24}
N 6490 -1690 6510 -1690 {lab=#net24}
N 6510 -1630 6570 -1630 {lab=#net24}
N 6570 -1660 6570 -1630 {lab=#net24}
N 6050 -1630 6150 -1630 {lab=#net23}
N 6450 -1750 6570 -1750 {lab=Vout_2}
N 8440 -1750 8620 -1750 {lab=Vout_2}
N 6710 -1480 6710 -1380 {lab=#net25}
N 6080 -1350 6670 -1350 {lab=#net26}
N 6010 -1410 6010 -1380 {lab=#net26}
N 6080 -1410 6080 -1350 {lab=#net26}
N 6050 -1350 6080 -1350 {lab=#net26}
N 6010 -1410 6080 -1410 {lab=#net26}
N 6010 -1600 6010 -1410 {lab=#net26}
N 6570 -1630 6670 -1630 {lab=#net24}
N 6360 -1390 6570 -1390 {lab=#net27}
N 6290 -1210 6320 -1210 {lab=Ibias_5}
N 6290 -1270 6290 -1210 {lab=Ibias_5}
N 6260 -1210 6290 -1210 {lab=Ibias_5}
N 6220 -1270 6290 -1270 {lab=Ibias_5}
N 6220 -1270 6220 -1240 {lab=Ibias_5}
N 6360 -1390 6360 -1240 {lab=#net27}
N 6150 -1390 6360 -1390 {lab=#net27}
N 8980 -1140 9730 -1140 {lab=VSS}
N 6150 -1270 6220 -1270 {lab=Ibias_5}
N 6610 -1450 6630 -1450 {lab=Vx1}
N 6090 -1450 6110 -1450 {lab=Vb0v4}
N 6570 -1140 6570 -1100 {lab=VSS}
N 6570 -1790 6570 -1750 {lab=Vout_2}
N 6710 -1480 6830 -1480 {lab=#net25}
N 6710 -1600 6710 -1480 {lab=#net25}
N 6360 -1140 6570 -1140 {lab=VSS}
N 6830 -1630 6850 -1630 {lab=#net25}
N 6830 -1480 6830 -1350 {lab=#net25}
N 6830 -1350 6850 -1350 {lab=#net25}
N 6830 -1630 6830 -1480 {lab=#net25}
N 7010 -1630 7030 -1630 {lab=#net28}
N 7010 -1480 7010 -1350 {lab=#net28}
N 7010 -1350 7030 -1350 {lab=#net28}
N 6890 -1480 6890 -1380 {lab=#net28}
N 6890 -1480 7010 -1480 {lab=#net28}
N 6890 -1600 6890 -1480 {lab=#net28}
N 7010 -1630 7010 -1480 {lab=#net28}
N 7070 -1480 7070 -1380 {lab=#net29}
N 7190 -1630 7210 -1630 {lab=#net29}
N 7190 -1350 7210 -1350 {lab=#net29}
N 7250 -1480 7250 -1380 {lab=X}
N 7190 -1480 7190 -1350 {lab=#net29}
N 7070 -1480 7190 -1480 {lab=#net29}
N 7190 -1630 7190 -1480 {lab=#net29}
N 7250 -1480 7310 -1480 {lab=X}
N 7250 -1600 7250 -1480 {lab=X}
N 7070 -1600 7070 -1480 {lab=#net29}
N 7940 -1690 7960 -1690 {lab=#net30}
N 8240 -1690 8260 -1690 {lab=#net31}
N 8000 -1570 8180 -1630 {lab=#net30}
N 7880 -1570 8000 -1570 {lab=#net30}
N 8000 -1630 8180 -1570 {lab=#net31}
N 8180 -1570 8300 -1570 {lab=#net31}
N 7880 -1570 7880 -1480 {lab=#net30}
N 7880 -1630 7880 -1570 {lab=#net30}
N 8000 -1660 8000 -1630 {lab=#net31}
N 8180 -1660 8180 -1630 {lab=#net30}
N 8300 -1570 8300 -1480 {lab=#net31}
N 8300 -1630 8300 -1570 {lab=#net31}
N 7940 -1690 7940 -1630 {lab=#net30}
N 7920 -1690 7940 -1690 {lab=#net30}
N 7880 -1630 7940 -1630 {lab=#net30}
N 7880 -1660 7880 -1630 {lab=#net30}
N 8240 -1690 8240 -1630 {lab=#net31}
N 8220 -1690 8240 -1690 {lab=#net31}
N 8240 -1630 8300 -1630 {lab=#net31}
N 8300 -1660 8300 -1630 {lab=#net31}
N 7780 -1630 7880 -1630 {lab=#net30}
N 8440 -1480 8440 -1380 {lab=#net32}
N 7810 -1350 8400 -1350 {lab=#net33}
N 7740 -1410 7740 -1380 {lab=#net33}
N 7810 -1410 7810 -1350 {lab=#net33}
N 7780 -1350 7810 -1350 {lab=#net33}
N 7740 -1410 7810 -1410 {lab=#net33}
N 7740 -1600 7740 -1410 {lab=#net33}
N 8300 -1630 8400 -1630 {lab=#net31}
N 8020 -1210 8050 -1210 {lab=Ibias_6}
N 8020 -1270 8020 -1210 {lab=Ibias_6}
N 7990 -1210 8020 -1210 {lab=Ibias_6}
N 7950 -1270 8020 -1270 {lab=Ibias_6}
N 7950 -1270 7950 -1240 {lab=Ibias_6}
N 8090 -1390 8090 -1240 {lab=#net34}
N 7880 -1390 8090 -1390 {lab=#net34}
N 7880 -1270 7950 -1270 {lab=Ibias_6}
N 8340 -1450 8360 -1450 {lab=Vx2}
N 7820 -1450 7840 -1450 {lab=Vb0v5}
N 8440 -1480 8560 -1480 {lab=#net32}
N 8440 -1600 8440 -1480 {lab=#net32}
N 8560 -1630 8580 -1630 {lab=#net32}
N 8560 -1480 8560 -1350 {lab=#net32}
N 8560 -1350 8580 -1350 {lab=#net32}
N 8560 -1630 8560 -1480 {lab=#net32}
N 8740 -1630 8760 -1630 {lab=#net35}
N 8740 -1480 8740 -1350 {lab=#net35}
N 8740 -1350 8760 -1350 {lab=#net35}
N 8620 -1480 8620 -1380 {lab=#net35}
N 8620 -1480 8740 -1480 {lab=#net35}
N 8620 -1600 8620 -1480 {lab=#net35}
N 8740 -1630 8740 -1480 {lab=#net35}
N 8800 -1480 8800 -1380 {lab=#net36}
N 8920 -1630 8940 -1630 {lab=#net36}
N 8920 -1350 8940 -1350 {lab=#net36}
N 8980 -1480 8980 -1380 {lab=Y}
N 8920 -1480 8920 -1350 {lab=#net36}
N 8800 -1480 8920 -1480 {lab=#net36}
N 8920 -1630 8920 -1480 {lab=#net36}
N 8980 -1480 9040 -1480 {lab=Y}
N 8980 -1600 8980 -1480 {lab=Y}
N 8800 -1600 8800 -1480 {lab=#net36}
N 5650 -1790 5650 -1770 {lab=Vx1}
N 5550 -1790 5600 -1790 {lab=Vx1}
N 5550 -1790 5550 -1770 {lab=Vx1}
N 5580 -1730 5600 -1730 {lab=Vx1}
N 5600 -1790 5600 -1730 {lab=Vx1}
N 5600 -1790 5650 -1790 {lab=Vx1}
N 5600 -1730 5620 -1730 {lab=Vx1}
N 5600 -1730 5600 -1600 {lab=Vx1}
N 5650 -1460 5650 -1440 {lab=Vx2}
N 5550 -1460 5600 -1460 {lab=Vx2}
N 5550 -1460 5550 -1440 {lab=Vx2}
N 5580 -1400 5600 -1400 {lab=Vx2}
N 5600 -1460 5600 -1400 {lab=Vx2}
N 5600 -1460 5650 -1460 {lab=Vx2}
N 5600 -1400 5620 -1400 {lab=Vx2}
N 5600 -1400 5600 -1290 {lab=Vx2}
N 6100 -640 6100 -610 {lab=wellb1}
N 6100 -550 6100 -520 {lab=Vout_2}
N 6010 -1750 6010 -1660 {lab=Vout_2}
N 6150 -1750 6150 -1720 {lab=Vout_2}
N 6010 -1750 6150 -1750 {lab=Vout_2}
N 6270 -1750 6270 -1720 {lab=Vout_2}
N 6150 -1750 6270 -1750 {lab=Vout_2}
N 6450 -1750 6450 -1720 {lab=Vout_2}
N 6270 -1750 6450 -1750 {lab=Vout_2}
N 6570 -1750 6570 -1720 {lab=Vout_2}
N 6710 -1750 6710 -1660 {lab=Vout_2}
N 6570 -1750 6710 -1750 {lab=Vout_2}
N 5940 -1630 6010 -1630 {lab=wellb1}
N 6070 -1690 6150 -1690 {lab=wellb1}
N 6350 -1690 6450 -1690 {lab=wellb1}
N 6570 -1690 6650 -1690 {lab=wellb1}
N 6710 -1630 6770 -1630 {lab=wellb1}
N 6350 -1730 6350 -1690 {lab=wellb1}
N 6270 -1690 6350 -1690 {lab=wellb1}
N 6890 -1750 6890 -1660 {lab=Vout_2}
N 6710 -1750 6890 -1750 {lab=Vout_2}
N 7070 -1750 7070 -1660 {lab=Vout_2}
N 6890 -1750 7070 -1750 {lab=Vout_2}
N 7250 -1750 7250 -1660 {lab=Vout_2}
N 7070 -1750 7250 -1750 {lab=Vout_2}
N 6770 -1680 6770 -1630 {lab=wellb1}
N 7140 -1680 7320 -1680 {lab=wellb1}
N 7320 -1680 7320 -1630 {lab=wellb1}
N 7250 -1630 7320 -1630 {lab=wellb1}
N 7070 -1630 7140 -1630 {lab=wellb1}
N 7140 -1680 7140 -1630 {lab=wellb1}
N 6960 -1680 7140 -1680 {lab=wellb1}
N 6890 -1630 6960 -1630 {lab=wellb1}
N 6960 -1680 6960 -1630 {lab=wellb1}
N 6770 -1680 6960 -1680 {lab=wellb1}
N 6770 -1700 6770 -1680 {lab=wellb1}
N 8980 -1750 8980 -1660 {lab=Vout_2}
N 8800 -1750 8800 -1660 {lab=Vout_2}
N 8620 -1750 8800 -1750 {lab=Vout_2}
N 8620 -1750 8620 -1660 {lab=Vout_2}
N 8440 -1630 8520 -1630 {lab=wellb1}
N 8520 -1690 8520 -1630 {lab=wellb1}
N 8870 -1690 9060 -1690 {lab=wellb1}
N 9060 -1690 9060 -1630 {lab=wellb1}
N 8980 -1630 9060 -1630 {lab=wellb1}
N 8800 -1630 8870 -1630 {lab=wellb1}
N 8870 -1690 8870 -1630 {lab=wellb1}
N 8680 -1690 8870 -1690 {lab=wellb1}
N 8620 -1630 8680 -1630 {lab=wellb1}
N 8680 -1690 8680 -1630 {lab=wellb1}
N 8520 -1690 8680 -1690 {lab=wellb1}
N 8520 -1710 8520 -1690 {lab=wellb1}
N 7740 -1750 7740 -1660 {lab=Vout_2}
N 7250 -1750 7740 -1750 {lab=Vout_2}
N 7880 -1750 7880 -1720 {lab=Vout_2}
N 7740 -1750 7880 -1750 {lab=Vout_2}
N 8000 -1750 8000 -1720 {lab=Vout_2}
N 7880 -1750 8000 -1750 {lab=Vout_2}
N 8180 -1750 8180 -1720 {lab=Vout_2}
N 8000 -1750 8180 -1750 {lab=Vout_2}
N 8300 -1750 8300 -1720 {lab=Vout_2}
N 8180 -1750 8300 -1750 {lab=Vout_2}
N 8300 -1690 8370 -1690 {lab=wellb1}
N 8090 -1690 8180 -1690 {lab=wellb1}
N 8090 -1710 8090 -1690 {lab=wellb1}
N 8000 -1690 8090 -1690 {lab=wellb1}
N 7810 -1690 7880 -1690 {lab=wellb1}
N 7670 -1630 7740 -1630 {lab=wellb1}
N 6200 -640 6200 -610 {lab=wellb1}
N 6200 -550 6200 -520 {lab=Vout_2}
N 5540 -1170 5540 -1150 {lab=wellu}
N 5540 -1090 5540 -1070 {lab=Vout_1}
N 5970 -540 5970 -520 {lab=Vout_2}
N 5970 -620 5970 -600 {lab=welld}
N 5680 -1400 5770 -1400 {lab=Vout_2}
N 5650 -1400 5650 -1330 {lab=welld}
N 5650 -1330 5730 -1330 {lab=welld}
N 5680 -1730 5760 -1730 {lab=Vout_1}
N 5650 -1730 5650 -1690 {lab=wellu}
N 5650 -1690 5710 -1690 {lab=wellu}
N 6100 -640 6200 -640 {lab=wellb1}
N 6200 -680 6200 -640 {lab=wellb1}
N 6100 -520 6200 -520 {lab=Vout_2}
N 5970 -520 6100 -520 {lab=Vout_2}
N 8440 -1750 8440 -1660 {lab=Vout_2}
N 8300 -1750 8440 -1750 {lab=Vout_2}
N 6570 -1420 6570 -1390 {lab=#net27}
N 6150 -1420 6150 -1390 {lab=#net27}
N 6440 -1450 6570 -1450 {lab=pt_well}
N 6360 -1480 6360 -1450 {lab=pt_well}
N 6150 -1450 6360 -1450 {lab=pt_well}
N 7880 -1420 7880 -1390 {lab=#net34}
N 8300 -1420 8300 -1390 {lab=#net34}
N 8180 -1450 8300 -1450 {lab=pt_well}
N 9930 -1380 9930 -1350 {lab=#net37}
N 9880 -1320 9890 -1320 {lab=#net38}
N 9930 -1430 9970 -1430 {lab=well}
N 9930 -1500 9930 -1460 {lab=Vout_2}
N 9880 -1430 9890 -1430 {lab=#net38}
N 9880 -1380 9880 -1320 {lab=#net38}
N 9930 -1380 10030 -1380 {lab=#net37}
N 9930 -1400 9930 -1380 {lab=#net37}
N 9930 -1320 9970 -1320 {lab=pt_well}
N 10030 -1320 10040 -1320 {lab=#net37}
N 10080 -1430 10120 -1430 {lab=well}
N 10080 -1500 10080 -1460 {lab=Vout_2}
N 10030 -1430 10040 -1430 {lab=#net37}
N 10030 -1380 10030 -1320 {lab=#net37}
N 10030 -1430 10030 -1380 {lab=#net37}
N 10080 -1380 10080 -1350 {lab=#net39}
N 10080 -1320 10120 -1320 {lab=pt_well}
N 10230 -1380 10230 -1350 {lab=#net40}
N 10180 -1320 10190 -1320 {lab=#net39}
N 10230 -1430 10270 -1430 {lab=well}
N 10230 -1500 10230 -1460 {lab=Vout_2}
N 10180 -1430 10190 -1430 {lab=#net39}
N 10230 -1380 10330 -1380 {lab=#net40}
N 10230 -1400 10230 -1380 {lab=#net40}
N 10230 -1320 10270 -1320 {lab=pt_well}
N 10330 -1320 10340 -1320 {lab=#net40}
N 10380 -1430 10420 -1430 {lab=well}
N 10380 -1500 10380 -1460 {lab=Vout_2}
N 10330 -1430 10340 -1430 {lab=#net40}
N 10330 -1380 10330 -1320 {lab=#net40}
N 10330 -1430 10330 -1380 {lab=#net40}
N 10380 -1380 10380 -1350 {lab=#net41}
N 10380 -1320 10420 -1320 {lab=pt_well}
N 10080 -1380 10180 -1380 {lab=#net39}
N 10180 -1380 10180 -1320 {lab=#net39}
N 10080 -1400 10080 -1380 {lab=#net39}
N 10180 -1430 10180 -1380 {lab=#net39}
N 10380 -1380 10480 -1380 {lab=#net41}
N 10380 -1400 10380 -1380 {lab=#net41}
N 10530 -1380 10530 -1350 {lab=#net42}
N 10480 -1320 10490 -1320 {lab=#net41}
N 10530 -1430 10570 -1430 {lab=well}
N 10530 -1500 10530 -1460 {lab=Vout_2}
N 10480 -1430 10490 -1430 {lab=#net41}
N 10480 -1380 10480 -1320 {lab=#net41}
N 10530 -1380 10630 -1380 {lab=#net42}
N 10530 -1400 10530 -1380 {lab=#net42}
N 10530 -1320 10570 -1320 {lab=pt_well}
N 10630 -1320 10640 -1320 {lab=#net42}
N 10680 -1430 10720 -1430 {lab=well}
N 10680 -1500 10680 -1460 {lab=Vout_2}
N 10630 -1430 10640 -1430 {lab=#net42}
N 10630 -1380 10630 -1320 {lab=#net42}
N 10630 -1430 10630 -1380 {lab=#net42}
N 10680 -1380 10680 -1350 {lab=#net43}
N 10680 -1320 10720 -1320 {lab=pt_well}
N 10830 -1380 10830 -1350 {lab=#net44}
N 10780 -1320 10790 -1320 {lab=#net43}
N 10830 -1430 10870 -1430 {lab=well}
N 10830 -1500 10830 -1460 {lab=Vout_2}
N 10780 -1430 10790 -1430 {lab=#net43}
N 10830 -1380 10930 -1380 {lab=#net44}
N 10830 -1400 10830 -1380 {lab=#net44}
N 10830 -1320 10870 -1320 {lab=pt_well}
N 10930 -1320 10940 -1320 {lab=#net44}
N 10980 -1430 11020 -1430 {lab=well}
N 10980 -1500 10980 -1460 {lab=Vout_2}
N 10930 -1430 10940 -1430 {lab=#net44}
N 10930 -1380 10930 -1320 {lab=#net44}
N 10930 -1430 10930 -1380 {lab=#net44}
N 10980 -1320 11020 -1320 {lab=pt_well}
N 10680 -1380 10780 -1380 {lab=#net43}
N 10780 -1380 10780 -1320 {lab=#net43}
N 10680 -1400 10680 -1380 {lab=#net43}
N 10780 -1430 10780 -1380 {lab=#net43}
N 10980 -1380 10980 -1350 {lab=#net45}
N 10480 -1430 10480 -1380 {lab=#net41}
N 11080 -1320 11090 -1320 {lab=#net45}
N 11130 -1430 11170 -1430 {lab=well}
N 11130 -1500 11130 -1460 {lab=Vout_2}
N 11130 -1290 11130 -1250 {lab=VSS}
N 11080 -1430 11090 -1430 {lab=#net45}
N 11080 -1380 11080 -1320 {lab=#net45}
N 11130 -1380 11130 -1350 {lab=#net46}
N 11130 -1320 11170 -1320 {lab=pt_well}
N 11280 -1380 11280 -1350 {lab=#net47}
N 11230 -1320 11240 -1320 {lab=#net46}
N 11280 -1430 11320 -1430 {lab=well}
N 11280 -1500 11280 -1460 {lab=Vout_2}
N 11280 -1290 11280 -1250 {lab=VSS}
N 11230 -1430 11240 -1430 {lab=#net46}
N 11280 -1380 11380 -1380 {lab=#net47}
N 11280 -1400 11280 -1380 {lab=#net47}
N 11280 -1320 11320 -1320 {lab=pt_well}
N 11380 -1320 11390 -1320 {lab=#net47}
N 11430 -1430 11470 -1430 {lab=well}
N 11430 -1500 11430 -1460 {lab=Vout_2}
N 11430 -1290 11430 -1250 {lab=VSS}
N 11380 -1430 11390 -1430 {lab=#net47}
N 11380 -1380 11380 -1320 {lab=#net47}
N 11380 -1430 11380 -1380 {lab=#net47}
N 11430 -1320 11470 -1320 {lab=pt_well}
N 11130 -1380 11230 -1380 {lab=#net46}
N 11230 -1380 11230 -1320 {lab=#net46}
N 11130 -1400 11130 -1380 {lab=#net46}
N 11230 -1430 11230 -1380 {lab=#net46}
N 10980 -1380 11080 -1380 {lab=#net45}
N 10980 -1400 10980 -1380 {lab=#net45}
N 11080 -1430 11080 -1380 {lab=#net45}
N 11680 -1380 11680 -1350 {lab=#net48}
N 11830 -1380 11830 -1350 {lab=#net49}
N 11630 -1430 11640 -1430 {lab=#net38}
N 11780 -1430 11790 -1430 {lab=#net48}
N 11680 -1430 11730 -1430 {lab=well}
N 11680 -1320 11730 -1320 {lab=pt_well}
N 11680 -1380 11780 -1380 {lab=#net48}
N 11680 -1400 11680 -1380 {lab=#net48}
N 11830 -1430 11880 -1430 {lab=well}
N 11780 -1430 11780 -1380 {lab=#net48}
N 11430 -1380 11430 -1350 {lab=#net38}
N 9930 -1500 10080 -1500 {lab=Vout_2}
N 10080 -1500 10230 -1500 {lab=Vout_2}
N 10230 -1500 10380 -1500 {lab=Vout_2}
N 10380 -1500 10530 -1500 {lab=Vout_2}
N 10530 -1500 10680 -1500 {lab=Vout_2}
N 10680 -1500 10830 -1500 {lab=Vout_2}
N 10830 -1500 10980 -1500 {lab=Vout_2}
N 10980 -1500 11130 -1500 {lab=Vout_2}
N 11130 -1500 11280 -1500 {lab=Vout_2}
N 11340 -1500 11430 -1500 {lab=Vout_2}
N 11680 -1500 11830 -1500 {lab=Vout_2}
N 9780 -1380 9880 -1380 {lab=#net38}
N 9880 -1430 9880 -1380 {lab=#net38}
N 10980 -1250 11130 -1250 {lab=VSS}
N 9780 -1550 9780 -1380 {lab=#net38}
N 11430 -1380 11530 -1380 {lab=#net38}
N 11430 -1400 11430 -1380 {lab=#net38}
N 11530 -1550 11530 -1380 {lab=#net38}
N 11530 -1380 11630 -1380 {lab=#net38}
N 11630 -1430 11630 -1380 {lab=#net38}
N 11680 -1500 11680 -1460 {lab=Vout_2}
N 11430 -1500 11680 -1500 {lab=Vout_2}
N 11680 -1290 11680 -1250 {lab=VSS}
N 11830 -1500 11830 -1460 {lab=Vout_2}
N 11830 -1380 12230 -1380 {lab=#net49}
N 11830 -1400 11830 -1380 {lab=#net49}
N 11170 -720 11170 -700 {lab=well}
N 11170 -640 11170 -620 {lab=Vout_2}
N 11630 -1380 11630 -1320 {lab=#net38}
N 11630 -1320 11640 -1320 {lab=#net38}
N 11830 -1290 11830 -1250 {lab=VSS}
N 11830 -1320 11880 -1320 {lab=pt_well}
N 11780 -1380 11780 -1320 {lab=#net48}
N 11780 -1320 11790 -1320 {lab=#net48}
N 11680 -1250 11830 -1250 {lab=VSS}
N 11430 -1250 11680 -1250 {lab=VSS}
N 11280 -1250 11430 -1250 {lab=VSS}
N 11130 -1250 11280 -1250 {lab=VSS}
N 10980 -1290 10980 -1250 {lab=VSS}
N 10830 -1250 10980 -1250 {lab=VSS}
N 10830 -1290 10830 -1250 {lab=VSS}
N 10680 -1250 10830 -1250 {lab=VSS}
N 10680 -1290 10680 -1250 {lab=VSS}
N 10530 -1250 10680 -1250 {lab=VSS}
N 10530 -1290 10530 -1250 {lab=VSS}
N 10380 -1250 10530 -1250 {lab=VSS}
N 10380 -1290 10380 -1250 {lab=VSS}
N 10230 -1250 10380 -1250 {lab=VSS}
N 10230 -1290 10230 -1250 {lab=VSS}
N 9930 -1290 9930 -1250 {lab=VSS}
N 10080 -1250 10230 -1250 {lab=VSS}
N 10080 -1290 10080 -1250 {lab=VSS}
N 9930 -1250 10080 -1250 {lab=VSS}
N 12630 -1550 12630 -1510 {lab=#net50}
N 12570 -1620 12590 -1620 {lab=#net51}
N 12570 -1480 12590 -1480 {lab=#net51}
N 12050 -1150 12070 -1150 {lab=Y}
N 12050 -1080 12050 -1010 {lab=Y}
N 12050 -1010 12070 -1010 {lab=Y}
N 12410 -1050 12410 -1010 {lab=S2}
N 12410 -1010 12770 -1010 {lab=S2}
N 12410 -1010 12410 -930 {lab=S2}
N 12310 -930 12310 -890 {lab=S2}
N 12410 -930 12510 -930 {lab=S2}
N 12510 -930 12510 -890 {lab=S2}
N 12410 -790 12510 -790 {lab=VSS}
N 12410 -790 12410 -750 {lab=VSS}
N 12310 -790 12410 -790 {lab=VSS}
N 12330 -1770 12430 -1770 {lab=Vout_2}
N 12330 -1810 12330 -1770 {lab=Vout_2}
N 12230 -1770 12330 -1770 {lab=Vout_2}
N 12230 -1670 12230 -1630 {lab=#net51}
N 12330 -1630 12430 -1630 {lab=#net51}
N 12430 -1670 12430 -1630 {lab=#net51}
N 12330 -1630 12330 -1550 {lab=#net51}
N 12230 -1630 12330 -1630 {lab=#net51}
N 12330 -1550 12330 -1510 {lab=#net51}
N 12470 -1700 12510 -1700 {lab=#net49}
N 12510 -1700 12510 -1590 {lab=#net49}
N 12570 -1550 12570 -1480 {lab=#net51}
N 12630 -1310 12630 -750 {lab=VSS}
N 12310 -930 12410 -930 {lab=S2}
N 12050 -1700 12190 -1700 {lab=X}
N 12230 -1380 12290 -1380 {lab=#net49}
N 12230 -1590 12230 -1380 {lab=#net49}
N 12230 -1590 12510 -1590 {lab=#net49}
N 12110 -1080 12110 -1040 {lab=#net52}
N 11990 -1080 12050 -1080 {lab=Y}
N 12050 -1150 12050 -1080 {lab=Y}
N 12230 -1110 12230 -960 {lab=#net49}
N 12110 -1120 12110 -1080 {lab=#net52}
N 12570 -1620 12570 -1550 {lab=#net51}
N 12050 -1480 12290 -1480 {lab=X}
N 12050 -1700 12050 -1480 {lab=X}
N 11990 -1700 12050 -1700 {lab=X}
N 12110 -1810 12330 -1810 {lab=Vout_2}
N 12110 -1810 12110 -1250 {lab=Vout_2}
N 12330 -1550 12570 -1550 {lab=#net51}
N 12330 -1810 12630 -1810 {lab=Vout_2}
N 12410 -750 12630 -750 {lab=VSS}
N 12110 -750 12410 -750 {lab=VSS}
N 12630 -1550 12920 -1550 {lab=#net50}
N 12630 -1590 12630 -1550 {lab=#net50}
N 12330 -1870 12330 -1810 {lab=Vout_2}
N 12410 -750 12410 -690 {lab=VSS}
N 12330 -1310 12630 -1310 {lab=VSS}
N 12330 -1450 12330 -1410 {lab=#net53}
N 12410 -1150 12410 -1110 {lab=#net54}
N 12270 -1080 12270 -860 {lab=#net52}
N 12110 -1080 12270 -1080 {lab=#net52}
N 12550 -960 12550 -860 {lab=#net49}
N 12230 -960 12550 -960 {lab=#net49}
N 12270 -1180 12270 -1080 {lab=#net52}
N 12270 -1180 12370 -1180 {lab=#net52}
N 12230 -1380 12230 -1110 {lab=#net49}
N 12350 -1110 12350 -1080 {lab=#net49}
N 12230 -1110 12350 -1110 {lab=#net49}
N 12350 -1080 12370 -1080 {lab=#net49}
N 12230 -1770 12230 -1730 {lab=Vout_2}
N 12230 -1700 12430 -1700 {lab=well}
N 12430 -1770 12430 -1730 {lab=Vout_2}
N 12630 -1810 12630 -1650 {lab=Vout_2}
N 12630 -1620 12680 -1620 {lab=well}
N 12110 -1250 12110 -1180 {lab=Vout_2}
N 12110 -1150 12160 -1150 {lab=well}
N 12410 -1250 12410 -1210 {lab=Vout_2}
N 12110 -1250 12410 -1250 {lab=Vout_2}
N 12410 -1180 12460 -1180 {lab=well}
N 12410 -1080 12460 -1080 {lab=well}
N 12330 -1350 12330 -1310 {lab=VSS}
N 12330 -1480 12380 -1480 {lab=pt_well}
N 12330 -1380 12380 -1380 {lab=pt_well}
N 12630 -1450 12630 -1310 {lab=VSS}
N 12630 -1480 12740 -1480 {lab=pt_well}
N 12410 -860 12510 -860 {lab=pt_well}
N 12310 -830 12310 -790 {lab=VSS}
N 12510 -830 12510 -790 {lab=VSS}
N 12110 -980 12110 -750 {lab=VSS}
N 12110 -1010 12170 -1010 {lab=pt_well}
N 11310 -720 11310 -700 {lab=well}
N 11310 -640 11310 -620 {lab=Vout_2}
N 12980 -1550 12980 -1510 {lab=#net55}
N 12920 -1620 12940 -1620 {lab=#net50}
N 12920 -1550 12920 -1480 {lab=#net50}
N 12920 -1480 12940 -1480 {lab=#net50}
N 13140 -1550 13140 -1510 {lab=S1}
N 13080 -1620 13100 -1620 {lab=#net55}
N 13080 -1550 13080 -1480 {lab=#net55}
N 13080 -1480 13100 -1480 {lab=#net55}
N 12980 -1550 13080 -1550 {lab=#net55}
N 12980 -1590 12980 -1550 {lab=#net55}
N 13080 -1620 13080 -1550 {lab=#net55}
N 13060 -1430 13140 -1430 {lab=VSS}
N 13060 -1670 13140 -1670 {lab=Vout_1}
N 12920 -1620 12920 -1550 {lab=#net50}
N 13140 -1550 13180 -1550 {lab=S1}
N 13140 -1590 13140 -1550 {lab=S1}
N 13060 -1430 13060 -690 {lab=VSS}
N 12980 -1430 13060 -1430 {lab=VSS}
N 13060 -1710 13060 -1670 {lab=Vout_1}
N 12980 -1670 13060 -1670 {lab=Vout_1}
N 13020 -1710 13060 -1710 {lab=Vout_1}
N 12980 -1670 12980 -1650 {lab=Vout_1}
N 12980 -1450 12980 -1430 {lab=VSS}
N 13140 -1450 13140 -1430 {lab=VSS}
N 13140 -1670 13140 -1650 {lab=Vout_1}
N 12980 -1620 13030 -1620 {lab=well_1}
N 13140 -1620 13190 -1620 {lab=well_1}
N 12980 -1480 13030 -1480 {lab=pt_well}
N 13140 -1480 13190 -1480 {lab=pt_well}
N 13330 -1500 13330 -1480 {lab=well_1}
N 13330 -1420 13330 -1400 {lab=Vout_1}
N 11340 -1870 12330 -1870 {lab=Vout_2}
N 9780 -1550 11530 -1550 {lab=#net38}
N 11830 -1250 11830 -690 {lab=VSS}
N 11830 -690 12410 -690 {lab=VSS}
N 11230 -620 11310 -620 {lab=Vout_2}
N 11230 -620 11230 -590 {lab=Vout_2}
N 11170 -620 11230 -620 {lab=Vout_2}
N 12380 -1480 12380 -1380 {lab=pt_well}
N 12740 -1480 12740 -1380 {lab=pt_well}
N 13030 -1380 13190 -1380 {lab=pt_well}
N 13190 -1480 13190 -1380 {lab=pt_well}
N 12380 -1380 12740 -1380 {lab=pt_well}
N 13030 -1480 13030 -1380 {lab=pt_well}
N 12930 -1380 13030 -1380 {lab=pt_well}
N 12410 -860 12410 -810 {lab=pt_well}
N 12310 -860 12410 -860 {lab=pt_well}
N 12410 -810 12930 -810 {lab=pt_well}
N 12930 -1380 12930 -810 {lab=pt_well}
N 12740 -1380 12930 -1380 {lab=pt_well}
N 12170 -810 12410 -810 {lab=pt_well}
N 12170 -1010 12170 -810 {lab=pt_well}
N 11340 -1870 11340 -1500 {lab=Vout_2}
N 11280 -1500 11340 -1500 {lab=Vout_2}
N 8980 -1750 9740 -1750 {lab=Vout_2}
N 8800 -1750 8980 -1750 {lab=Vout_2}
N 9740 -1750 9740 -1500 {lab=Vout_2}
N 9740 -1500 9930 -1500 {lab=Vout_2}
N 9730 -1250 9930 -1250 {lab=VSS}
N 9730 -1250 9730 -1140 {lab=VSS}
N 12410 -690 13060 -690 {lab=VSS}
N 2220 -460 2540 -460 {lab=pt_well}
N 1840 -1070 1840 -1020 {lab=pt_well}
N 1720 -1070 1720 -1020 {lab=pt_well}
N 1620 -1070 1720 -1070 {lab=pt_well}
N 1620 -1070 1620 -1020 {lab=pt_well}
N 1460 -1070 1620 -1070 {lab=pt_well}
N 1840 -960 1840 -930 {lab=VSS}
N 1720 -930 1840 -930 {lab=VSS}
N 1720 -960 1720 -930 {lab=VSS}
N 1620 -930 1720 -930 {lab=VSS}
N 1620 -960 1620 -930 {lab=VSS}
N 6220 -1180 6220 -1140 {lab=VSS}
N 6010 -1140 6220 -1140 {lab=VSS}
N 6360 -1180 6360 -1140 {lab=VSS}
N 6220 -1140 6360 -1140 {lab=VSS}
N 6010 -1320 6010 -1140 {lab=VSS}
N 6360 -1210 6440 -1210 {lab=pt_well}
N 6440 -1450 6440 -1210 {lab=pt_well}
N 6360 -1450 6440 -1450 {lab=pt_well}
N 5920 -1350 6010 -1350 {lab=pt_well}
N 5920 -1350 5920 -1090 {lab=pt_well}
N 6440 -1210 6440 -1090 {lab=pt_well}
N 6110 -1090 6440 -1090 {lab=pt_well}
N 6110 -1210 6220 -1210 {lab=pt_well}
N 6110 -1210 6110 -1090 {lab=pt_well}
N 5920 -1090 6110 -1090 {lab=pt_well}
N 6710 -1320 6710 -1140 {lab=VSS}
N 6570 -1140 6710 -1140 {lab=VSS}
N 6890 -1320 6890 -1140 {lab=VSS}
N 6710 -1140 6890 -1140 {lab=VSS}
N 7070 -1320 7070 -1140 {lab=VSS}
N 6890 -1140 7070 -1140 {lab=VSS}
N 7250 -1320 7250 -1140 {lab=VSS}
N 7070 -1140 7250 -1140 {lab=VSS}
N 6710 -1350 6800 -1350 {lab=pt_well}
N 6800 -1350 6800 -1090 {lab=pt_well}
N 6440 -1090 6800 -1090 {lab=pt_well}
N 6890 -1350 6990 -1350 {lab=pt_well}
N 6990 -1350 6990 -1090 {lab=pt_well}
N 6800 -1090 6990 -1090 {lab=pt_well}
N 7070 -1350 7160 -1350 {lab=pt_well}
N 7160 -1350 7160 -1090 {lab=pt_well}
N 6990 -1090 7160 -1090 {lab=pt_well}
N 7250 -1350 7360 -1350 {lab=pt_well}
N 7360 -1350 7360 -1090 {lab=pt_well}
N 7950 -1180 7950 -1140 {lab=VSS}
N 7740 -1140 7950 -1140 {lab=VSS}
N 8090 -1180 8090 -1140 {lab=VSS}
N 7950 -1140 8090 -1140 {lab=VSS}
N 7740 -1320 7740 -1140 {lab=VSS}
N 7250 -1140 7740 -1140 {lab=VSS}
N 7160 -1090 7360 -1090 {lab=pt_well}
N 8180 -1210 8180 -1090 {lab=pt_well}
N 8090 -1390 8300 -1390 {lab=#net34}
N 7840 -1090 8180 -1090 {lab=pt_well}
N 8090 -1210 8180 -1210 {lab=pt_well}
N 7840 -1210 7950 -1210 {lab=pt_well}
N 7840 -1210 7840 -1090 {lab=pt_well}
N 7640 -1090 7840 -1090 {lab=pt_well}
N 7640 -1350 7740 -1350 {lab=pt_well}
N 7640 -1350 7640 -1090 {lab=pt_well}
N 7360 -1090 7640 -1090 {lab=pt_well}
N 8180 -1450 8180 -1210 {lab=pt_well}
N 7880 -1450 8180 -1450 {lab=pt_well}
N 8440 -1320 8440 -1140 {lab=VSS}
N 8090 -1140 8440 -1140 {lab=VSS}
N 8620 -1320 8620 -1140 {lab=VSS}
N 8440 -1140 8620 -1140 {lab=VSS}
N 8800 -1320 8800 -1140 {lab=VSS}
N 8620 -1140 8800 -1140 {lab=VSS}
N 8980 -1320 8980 -1140 {lab=VSS}
N 8800 -1140 8980 -1140 {lab=VSS}
N 8440 -1350 8540 -1350 {lab=pt_well}
N 8540 -1350 8540 -1090 {lab=pt_well}
N 8180 -1090 8540 -1090 {lab=pt_well}
N 8620 -1350 8720 -1350 {lab=pt_well}
N 8720 -1350 8720 -1090 {lab=pt_well}
N 8540 -1090 8720 -1090 {lab=pt_well}
N 8800 -1350 8890 -1350 {lab=pt_well}
N 8890 -1350 8890 -1090 {lab=pt_well}
N 8720 -1090 8890 -1090 {lab=pt_well}
N 8980 -1350 9080 -1350 {lab=pt_well}
N 9080 -1350 9080 -1090 {lab=pt_well}
N 8890 -1090 9080 -1090 {lab=pt_well}
N 11880 -1320 11880 -1090 {lab=pt_well}
N 11730 -1090 11880 -1090 {lab=pt_well}
N 9970 -1320 9970 -1090 {lab=pt_well}
N 9080 -1090 9970 -1090 {lab=pt_well}
N 10120 -1320 10120 -1090 {lab=pt_well}
N 9970 -1090 10120 -1090 {lab=pt_well}
N 10270 -1320 10270 -1090 {lab=pt_well}
N 10120 -1090 10270 -1090 {lab=pt_well}
N 10420 -1320 10420 -1090 {lab=pt_well}
N 10270 -1090 10420 -1090 {lab=pt_well}
N 10570 -1320 10570 -1090 {lab=pt_well}
N 10420 -1090 10570 -1090 {lab=pt_well}
N 10720 -1320 10720 -1090 {lab=pt_well}
N 10570 -1090 10720 -1090 {lab=pt_well}
N 10870 -1320 10870 -1090 {lab=pt_well}
N 10720 -1090 10870 -1090 {lab=pt_well}
N 11020 -1320 11020 -1090 {lab=pt_well}
N 10870 -1090 11020 -1090 {lab=pt_well}
N 11170 -1320 11170 -1090 {lab=pt_well}
N 11020 -1090 11170 -1090 {lab=pt_well}
N 11320 -1320 11320 -1090 {lab=pt_well}
N 11170 -1090 11320 -1090 {lab=pt_well}
N 11470 -1320 11470 -1090 {lab=pt_well}
N 11320 -1090 11470 -1090 {lab=pt_well}
N 11730 -1320 11730 -1090 {lab=pt_well}
N 11470 -1090 11730 -1090 {lab=pt_well}
N 12930 -810 12930 -780 {lab=pt_well}
N 5460 -1400 5520 -1400 {lab=VSS}
N 5550 -1400 5550 -1300 {lab=pt_well}
N 5460 -1730 5530 -1730 {lab=VSS}
N 5550 -1730 5550 -1600 {lab=pt_well}
N 7190 -680 7190 -650 {lab=pt_well}
N 7190 -590 7190 -540 {lab=VSS}
N 7320 -680 7320 -650 {lab=pt_well}
N 7190 -680 7320 -680 {lab=pt_well}
N 7190 -710 7190 -680 {lab=pt_well}
N 7190 -540 7320 -540 {lab=VSS}
N 7320 -590 7320 -540 {lab=VSS}
N 7430 -680 7430 -650 {lab=pt_well}
N 7430 -590 7430 -540 {lab=VSS}
N 7560 -680 7560 -650 {lab=pt_well}
N 7430 -680 7560 -680 {lab=pt_well}
N 7430 -540 7560 -540 {lab=VSS}
N 7560 -590 7560 -540 {lab=VSS}
N 7320 -680 7430 -680 {lab=pt_well}
N 7320 -540 7430 -540 {lab=VSS}
N 7560 -680 7640 -680 {lab=pt_well}
N 7640 -680 7640 -650 {lab=pt_well}
N 7640 -590 7640 -540 {lab=VSS}
N 7560 -540 7640 -540 {lab=VSS}
N 7640 -680 7760 -680 {lab=pt_well}
N 7760 -680 7760 -650 {lab=pt_well}
N 7760 -590 7760 -540 {lab=VSS}
N 7640 -540 7760 -540 {lab=VSS}
N 7760 -680 7850 -680 {lab=pt_well}
N 7850 -680 7850 -650 {lab=pt_well}
N 7850 -590 7850 -540 {lab=VSS}
N 7760 -540 7850 -540 {lab=VSS}
N 7170 -540 7190 -540 {lab=VSS}
C {sg13g2_pr/sg13_lv_pmos.sym} 1780 -1780 0 0 {name=M1
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1980 -1780 0 0 {name=M2
l=2u
w=1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2390 -1780 0 1 {name=M3
l=2u
w=1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2570 -1780 0 1 {name=M4
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1130 -1780 0 1 {name=M12
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1380 -1780 0 1 {name=M13
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2990 -1780 0 0 {name=M5
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1340 -1390 0 0 {name=M7
l=1.2u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1090 -1240 0 0 {name=M10
l=1.2u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1090 -1360 0 0 {name=M11
l=0.26u
w=10u
ng=1
m=30
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1340 -1510 0 0 {name=M16
l=0.26u
w=10u
ng=1
m=30
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2530 -1410 0 0 {name=M24
l=0.36u
w=10u
ng=1
m=20
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2530 -1520 0 0 {name=M25
l=0.36u
w=10u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 3010 -1390 0 0 {name=R1
w=0.5e-6
l=1170e-6
model=rppd
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rhigh.sym} 3010 -1270 0 0 {name=R3
w=0.5e-6
l=27e-6
model=rhigh
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1800 -1410 0 0 {name=R10
w=0.5e-6
l=2110e-6
model=rppd
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3150 -1780 0 0 {name=M6
l=2u
w=1u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1500 -2260 0 0 {name=M8
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1540 -2460 0 1 {name=M9
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 1850 -2460 0 0 {name=M14
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1890 -2260 0 1 {name=M15
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/ntap1.sym} 1730 -2390 0 1 {name=R2
model=ntap1
spiceprefix=X
w=1e-6
l=20e-6
}
C {sg13g2_pr/ptap1.sym} 1620 -990 2 0 {name=R4_opamp
model=ptap1
spiceprefix=X
w=56e-6
l=1e-6
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2770 -2200 0 0 {name=M17
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2810 -2400 0 1 {name=M18
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3120 -2400 0 0 {name=M19
l=0.5u
w=10u
ng=1
m=4
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3160 -2200 0 1 {name=M20
l=8u
w=10u
ng=1
m=6
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/ntap1.sym} 3000 -2330 0 1 {name=R5
model=ntap1
spiceprefix=X
w=1e-6
l=20e-6
}
C {sg13g2_pr/ptap1.sym} 1840 -990 2 0 {name=R6_opamp
model=ptap1
spiceprefix=X
w=56e-6
l=1e-6
}
C {sg13g2_pr/ntap1.sym} 2360 -2020 1 0 {name=R7
model=ntap1
spiceprefix=X
w=5e-6
l=1e-6
}
C {sg13g2_pr/ntap1.sym} 2360 -2100 1 0 {name=R8
model=ntap1
spiceprefix=X
w=5e-6
l=1e-6
}
C {sg13g2_pr/ntap1.sym} 2650 -1610 0 1 {name=R9
model=ntap1
spiceprefix=X
w=1e-6
l=8e-6
}
C {sg13g2_pr/ptap1.sym} 1720 -990 2 0 {name=R11_PTAT
model=ptap1
spiceprefix=X
w=1e-6
l=19e-6
}
C {iopin.sym} 2640 -720 0 0 {name=p4 lab=Ibias_1}
C {iopin.sym} 2800 -720 0 0 {name=p5 lab=Ibias_2}
C {iopin.sym} 2940 -720 0 0 {name=p6 lab=Ibias_3}
C {iopin.sym} 3080 -720 0 0 {name=p7 lab=Ibias_4}
C {sg13g2_pr/sg13_lv_nmos.sym} 2350 -670 0 1 {name=M30
l=2u
w=1.1u
ng=1
m=3
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 3730 -720 0 0 {name=R4
w=0.5e-6
l=972.9e-6
model=rppd
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 3910 -720 0 0 {name=R6
w=0.5e-6
l=1167.4e-6
model=rppd
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2410 -670 0 0 {name=M21
l=2u
w=1.1u
ng=1
m=3
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2450 -800 0 1 {name=M23
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2620 -800 0 0 {name=M22
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2780 -800 0 0 {name=M26
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 2920 -800 0 0 {name=M27
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3060 -790 0 0 {name=M28
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3210 -800 0 0 {name=M29
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3370 -800 0 0 {name=M31
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/cap_cmim.sym} 2380 -600 0 0 {name=C5
model=cap_cmim
w=18e-6
l=18e-6
m=9
spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 2580 -900 0 0 {name=C2
model=cap_cmim
w=2.6e-6
l=2.6e-6
m=1
spiceprefix=X}
C {sg13g2_pr/ntap1.sym} 4110 -550 0 0 {name=R11
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4180 -550 0 0 {name=R12
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4280 -550 0 0 {name=R13
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4350 -550 0 0 {name=R14
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4440 -550 0 0 {name=R15
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4510 -550 0 0 {name=R16
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4610 -550 0 0 {name=R17
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4680 -550 0 0 {name=R18
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ntap1.sym} 4780 -550 0 0 {name=R19
model=ntap1
spiceprefix=X
w=6e-6
l=0.7e-6
}
C {sg13g2_pr/ptap1.sym} 2620 -460 1 0 {name=R20
model=ptap1
spiceprefix=X
w=1e-6
l=5e-6
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3710 -800 0 0 {name=M32
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 3890 -800 0 0 {name=M33
l=2u
w=1.1u
ng=1
m=6
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 3730 -620 0 0 {name=R21
w=0.5e-6
l=994e-6
model=rppd
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 3910 -620 0 0 {name=R22
w=0.5e-6
l=792e-6
model=rppd
body=VSS
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6170 -1690 0 1 {name=M34
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6250 -1690 0 0 {name=M35
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6470 -1690 0 1 {name=M36
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6550 -1690 0 0 {name=M37
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6130 -1450 0 0 {name=M38
l=0.5u
w=5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6590 -1450 0 1 {name=M39
l=0.5u
w=5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6340 -1210 0 0 {name=M40
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6030 -1630 0 1 {name=M41
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6690 -1630 0 0 {name=M42
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6690 -1350 0 0 {name=M43
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6030 -1350 0 1 {name=M44
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 6240 -1210 0 1 {name=M45
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {iopin.sym} 6570 -1100 0 1 {name=p3 lab=VSS}
C {iopin.sym} 6570 -1790 0 1 {name=p11 lab=Vout_2}
C {sg13g2_pr/sg13_lv_nmos.sym} 6870 -1350 0 0 {name=M46
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 6870 -1630 0 0 {name=M47
l=0.13u
w=1u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7050 -1350 0 0 {name=M48
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7050 -1630 0 0 {name=M49
l=0.13u
w=2u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7230 -1350 0 0 {name=M50
l=0.13u
w=3u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7230 -1630 0 0 {name=M51
l=0.13u
w=3u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7900 -1690 0 1 {name=M52
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7980 -1690 0 0 {name=M53
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8200 -1690 0 1 {name=M54
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8280 -1690 0 0 {name=M55
l=0.13u
w=0.5u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7860 -1450 0 0 {name=M56
l=0.5u
w=5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8320 -1450 0 1 {name=M57
l=0.5u
w=5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8070 -1210 0 0 {name=M58
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 7760 -1630 0 1 {name=M59
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8420 -1630 0 0 {name=M60
l=0.5u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8420 -1350 0 0 {name=M61
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7760 -1350 0 1 {name=M62
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 7970 -1210 0 1 {name=M63
l=0.5u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8600 -1350 0 0 {name=M64
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8600 -1630 0 0 {name=M65
l=0.13u
w=1u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8780 -1350 0 0 {name=M66
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8780 -1630 0 0 {name=M67
l=0.13u
w=2u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 8960 -1350 0 0 {name=M68
l=0.13u
w=3u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 8960 -1630 0 0 {name=M69
l=0.13u
w=3u
ng=1
m=2
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 5650 -1750 1 0 {name=M70
l=10u
w=0.5u
ng=1
m=19
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5550 -1750 1 0 {name=M71
l=10u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 5600 -1600 0 1 {name=p38 sig_type=std_logic lab=Vx1}
C {lab_pin.sym} 6630 -1450 0 1 {name=p12 sig_type=std_logic lab=Vx1}
C {sg13g2_pr/sg13_lv_pmos.sym} 5650 -1420 1 0 {name=M72
l=10u
w=0.5u
ng=1
m=10
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 5550 -1420 1 0 {name=M73
l=10u
w=0.5u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 5600 -1290 0 1 {name=p39 sig_type=std_logic lab=Vx2}
C {lab_pin.sym} 5770 -1400 0 1 {name=p28 sig_type=std_logic lab=Vout_2}
C {lab_pin.sym} 5460 -1400 0 0 {name=p13 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 5460 -1730 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {sg13g2_pr/ntap1.sym} 6100 -580 2 0 {name=R23
model=ntap1
spiceprefix=X
w=12.0e-6
l=1.0e-6
}
C {lab_pin.sym} 5940 -1630 2 1 {name=p18 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 8090 -1710 2 0 {name=p19 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 7670 -1630 2 1 {name=p20 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 7810 -1690 2 1 {name=p21 sig_type=std_logic lab=wellb1}
C {sg13g2_pr/ntap1.sym} 6200 -580 2 0 {name=R24
model=ntap1
spiceprefix=X
w=12.0e-6
l=1.0e-6
}
C {lab_pin.sym} 6200 -680 2 1 {name=p22 sig_type=std_logic lab=wellb1}
C {sg13g2_pr/ntap1.sym} 5540 -1120 2 0 {name=R25
model=ntap1
spiceprefix=X
w=10.0e-6
l=1.0e-6
}
C {sg13g2_pr/ntap1.sym} 5970 -570 2 0 {name=R26
model=ntap1
spiceprefix=X
w=10.0e-6
l=1.0e-6
}
C {lab_pin.sym} 5540 -1170 0 0 {name=p25 sig_type=std_logic lab=wellu}
C {lab_pin.sym} 5970 -620 0 0 {name=p26 sig_type=std_logic lab=welld}
C {lab_pin.sym} 5540 -1070 0 0 {name=p27 sig_type=std_logic lab=Vout_1}
C {lab_pin.sym} 5970 -520 0 0 {name=p29 sig_type=std_logic lab=Vout_2}
C {lab_pin.sym} 5710 -1690 0 1 {name=p31 sig_type=std_logic lab=wellu}
C {lab_pin.sym} 5730 -1330 0 1 {name=p32 sig_type=std_logic lab=welld}
C {lab_pin.sym} 6070 -1690 2 1 {name=p23 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 6350 -1730 2 1 {name=p24 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 6650 -1690 2 0 {name=p30 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 6770 -1700 2 0 {name=p33 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 8520 -1710 2 0 {name=p34 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 8370 -1690 2 0 {name=p35 sig_type=std_logic lab=wellb1}
C {lab_pin.sym} 8360 -1450 0 1 {name=p40 sig_type=std_logic lab=Vx2}
C {sg13g2_pr/sg13_lv_nmos.sym} 9910 -1320 0 0 {name=M74
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 9910 -1430 0 0 {name=M75
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 9970 -1430 2 0 {name=p43 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 10060 -1320 0 0 {name=M76
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10060 -1430 0 0 {name=M77
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 10120 -1430 2 0 {name=p45 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 10210 -1320 0 0 {name=M78
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10210 -1430 0 0 {name=M79
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 10270 -1430 2 0 {name=p46 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 10360 -1320 0 0 {name=M80
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10360 -1430 0 0 {name=M81
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 10420 -1430 2 0 {name=p47 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 10510 -1320 0 0 {name=M82
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10510 -1430 0 0 {name=M83
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 10570 -1430 2 0 {name=p48 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 10660 -1320 0 0 {name=M84
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10660 -1430 0 0 {name=M85
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 10720 -1430 2 0 {name=p49 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 10810 -1320 0 0 {name=M86
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10810 -1430 0 0 {name=M87
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 10870 -1430 2 0 {name=p50 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 10960 -1320 0 0 {name=M88
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 10960 -1430 0 0 {name=M89
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 11020 -1430 2 0 {name=p51 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 11110 -1320 0 0 {name=M90
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11110 -1430 0 0 {name=M91
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 11170 -1430 2 0 {name=p52 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 11260 -1320 0 0 {name=M92
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11260 -1430 0 0 {name=M93
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 11320 -1430 2 0 {name=p54 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 11410 -1320 0 0 {name=M94
l=1u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11410 -1430 0 0 {name=M95
l=1u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {lab_pin.sym} 11470 -1430 2 0 {name=p56 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_nmos.sym} 11660 -1320 0 0 {name=M96
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11660 -1430 0 0 {name=M97
l=0.13u
w=4u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 11810 -1430 0 0 {name=M98
l=0.13u
w=8u
ng=2
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 11810 -1320 0 0 {name=M99
l=0.13u
w=4u
ng=2
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_pin.sym} 11730 -1430 2 0 {name=p58 sig_type=std_logic lab=well}
C {lab_pin.sym} 11880 -1430 2 0 {name=p60 sig_type=std_logic lab=well}
C {sg13g2_pr/ntap1.sym} 11170 -670 2 0 {name=R27
model=ntap1
spiceprefix=X
w=29.0e-6
l=1.0e-6
}
C {lab_pin.sym} 11170 -720 2 1 {name=p64 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_pmos.sym} 12210 -1700 0 0 {name=M100
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12450 -1700 0 1 {name=M101
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12310 -1480 0 0 {name=M102
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12310 -1380 0 0 {name=M103
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12610 -1620 0 0 {name=M104
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12610 -1480 0 0 {name=M105
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12090 -1150 0 0 {name=M106
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12090 -1010 0 0 {name=M107
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12390 -1180 0 0 {name=M108
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 12390 -1080 0 0 {name=M109
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12290 -860 0 0 {name=M110
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12530 -860 0 1 {name=M111
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {opin.sym} 12770 -1010 0 0 {name=p67 lab=S2}
C {lab_pin.sym} 12330 -1700 3 0 {name=p68 sig_type=std_logic lab=well}
C {lab_pin.sym} 12680 -1620 2 0 {name=p69 sig_type=std_logic lab=well}
C {lab_pin.sym} 12160 -1150 2 0 {name=p70 sig_type=std_logic lab=well}
C {lab_pin.sym} 12460 -1180 2 0 {name=p71 sig_type=std_logic lab=well}
C {lab_pin.sym} 12460 -1080 2 0 {name=p72 sig_type=std_logic lab=well}
C {sg13g2_pr/ntap1.sym} 11310 -670 2 0 {name=R28
model=ntap1
spiceprefix=X
w=7.0e-6
l=1.0e-6
}
C {lab_pin.sym} 11310 -720 2 1 {name=p73 sig_type=std_logic lab=well}
C {sg13g2_pr/sg13_lv_pmos.sym} 12960 -1620 0 0 {name=M112
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 12960 -1480 0 0 {name=M113
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_pmos.sym} 13120 -1620 0 0 {name=M114
l=0.13u
w=2u
ng=1
m=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 13120 -1480 0 0 {name=M115
l=0.13u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {opin.sym} 13180 -1550 0 0 {name=p74 lab=S1}
C {iopin.sym} 13020 -1710 0 1 {name=p75 lab=Vout_1}
C {lab_pin.sym} 13030 -1620 2 0 {name=p76 sig_type=std_logic lab=well_1}
C {lab_pin.sym} 13190 -1620 2 0 {name=p77 sig_type=std_logic lab=well_1}
C {sg13g2_pr/ntap1.sym} 13330 -1450 2 0 {name=R29
model=ntap1
spiceprefix=X
w=2.0e-6
l=1.0e-6
}
C {lab_pin.sym} 13330 -1500 2 1 {name=p78 sig_type=std_logic lab=well_1}
C {lab_pin.sym} 13330 -1400 2 1 {name=p79 sig_type=std_logic lab=Vout_1}
C {lab_pin.sym} 11230 -590 2 1 {name=p80 sig_type=std_logic lab=Vout_2}
C {lab_pin.sym} 5760 -1730 0 1 {name=p62 sig_type=std_logic lab=Vout_1}
C {lab_pin.sym} 7310 -1480 0 1 {name=p53 sig_type=std_logic lab=X}
C {lab_pin.sym} 9040 -1480 0 1 {name=p55 sig_type=std_logic lab=Y}
C {lab_pin.sym} 11990 -1080 0 0 {name=p57 sig_type=std_logic lab=Y}
C {lab_pin.sym} 11990 -1700 0 0 {name=p63 sig_type=std_logic lab=X}
C {lab_pin.sym} 2010 -570 0 0 {name=p89 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 2180 -1930 0 1 {name=p10 sig_type=std_logic lab=Vout_2}
C {lab_pin.sym} 3960 -670 0 1 {name=p1 sig_type=std_logic lab=Vb0v4}
C {lab_pin.sym} 3760 -670 0 1 {name=p16 sig_type=std_logic lab=Vb0v5}
C {lab_pin.sym} 7820 -1450 0 0 {name=p17 sig_type=std_logic lab=Vb0v5}
C {lab_pin.sym} 6090 -1450 0 0 {name=p2 sig_type=std_logic lab=Vb0v4}
C {lab_pin.sym} 3230 -720 0 1 {name=p8 sig_type=std_logic lab=Ibias_5}
C {lab_pin.sym} 6150 -1270 0 0 {name=p15 sig_type=std_logic lab=Ibias_5}
C {lab_pin.sym} 7880 -1270 0 0 {name=p36 sig_type=std_logic lab=Ibias_6}
C {lab_pin.sym} 3390 -720 0 1 {name=p37 sig_type=std_logic lab=Ibias_6}
C {lab_pin.sym} 5550 -1600 0 0 {name=p42 sig_type=std_logic lab=pt_well}
C {lab_pin.sym} 5550 -1300 0 0 {name=p44 sig_type=std_logic lab=pt_well}
C {lab_pin.sym} 6360 -1480 0 0 {name=p59 sig_type=std_logic lab=pt_well}
C {lab_pin.sym} 12930 -780 0 0 {name=p61 sig_type=std_logic lab=pt_well}
C {sg13g2_pr/ptap1.sym} 7190 -620 2 0 {name=R30
model=ptap1
spiceprefix=X
w=13e-6
l=1e-6
}
C {sg13g2_pr/ptap1.sym} 7430 -620 2 0 {name=R32
model=ptap1
spiceprefix=X
w=10e-6
l=1e-6
}
C {lab_pin.sym} 7170 -540 0 0 {name=p65 sig_type=std_logic lab=VSS}
C {sg13g2_pr/ptap1.sym} 7640 -620 2 0 {name=R34
model=ptap1
spiceprefix=X
w=29e-6
l=1e-6
}
C {sg13g2_pr/ptap1.sym} 7760 -620 2 0 {name=R35
model=ptap1
spiceprefix=X
w=3e-6
l=1e-6
}
C {sg13g2_pr/ptap1.sym} 7850 -620 2 0 {name=R36
model=ptap1
spiceprefix=X
w=7e-6
l=1e-6
}
C {lab_pin.sym} 1460 -850 0 0 {name=p9 sig_type=std_logic lab=pt_well}
C {sg13g2_pr/ptap1.sym} 7320 -620 2 0 {name=R31
model=ptap1
spiceprefix=X
w=13e-6
l=1e-6
}
C {sg13g2_pr/ptap1.sym} 7560 -620 2 0 {name=R33
model=ptap1
spiceprefix=X
w=10e-6
l=1e-6
}
C {iopin.sym} 7190 -710 0 1 {name=p66 lab=pt_well}
